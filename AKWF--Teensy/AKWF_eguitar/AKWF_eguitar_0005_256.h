/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eguitar_0005 256 samples */
 
const int16_t AKWF_eguitar_0005_256_DATA [256] = 
{862, 2358, 4041, 6159, 8879, 12694, 19130, 29647, 33134, 32620, 32671, 32633, 32591, 32504, 32433, 32363, 32297, 32230, 32170, 32109, 32079, 32020, 31939, 31860, 31784, 31715, 31637, 31555, 31483, 31407, 31329, 31250, 31174, 31102, 31027, 30950, 30872, 30797, 30717, 30642, 30568, 30493, 30418, 30337, 30267, 30190, 30117, 30042, 29966, 29903, 29823, 29748, 29668, 29605, 29528, 29452, 29378, 29306, 29235, 29160, 29089, 29016, 28943, 28875, 28799, 28731, 28661, 28585, 28515, 28438, 28367, 28290, 28217, 28140, 28068, 27993, 27918, 27847, 27770, 27696, 27615, 27564, 27017, 25903, 24822, 23761, 22703, 21652, 20620, 19603, 18618, 17661, 16715, 15808, 14914, 14060, 13208, 12403, 11626, 10870, 10127, 9422, 8734, 8080, 7435, 6828, 6249, 5685, 5134, 4616, 4117, 3667, 3224, 2798, 2405, 2040, 1689, 1383, 1077, 802, 555, 319, 120, -72, -232, -383, -520, -622, -719, -801, -855, -896, -952, -1002, -1072, -1227, -1615, -2336, -3183, -3971, -4781, -5683, -6658, -7684, -8848, -10307, -12235, -14976, -19449, -27805, -31780, -31263, -31301, -31260, -31194, -31127, -31058, -30989, -30921, -30854, -30785, -30732, -30689, -30632, -30556, -30483, -30415, -30339, -30262, -30193, -30117, -30047, -29968, -29896, -29825, -29753, -29680, -29605, -29533, -29455, -29384, -29312, -29240, -29170, -29092, -29025, -28950, -28880, -28806, -28737, -28674, -28598, -28527, -28449, -28387, -28312, -28243, -28170, -28103, -28034, -27960, -27891, -27822, -27753, -27686, -27614, -27550, -27483, -27408, -27341, -27270, -27207, -27136, -27069, -26996, -26927, -26855, -26783, -26717, -26643, -26580, -26508, -26436, -26379, -26295, -26241, -25891, -25060, -24231, -23400, -22586, -21773, -20986, -20211, -19460, -18725, -17999, -17314, -16632, -15969, -15340, -14711, -14078, -13483, -12945, -12135, -9976, -8253, -7387, -6406, -5196, -4042, -3113, -2310, -1466, -513};