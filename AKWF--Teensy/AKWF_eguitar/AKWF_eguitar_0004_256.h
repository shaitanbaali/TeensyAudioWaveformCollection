/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eguitar_0004 256 samples */
 
const int16_t AKWF_eguitar_0004_256_DATA [256] = 
{9281, 25662, 25901, 24624, 24642, 25212, 24660, 24788, 25087, 24561, 24833, 24997, 24524, 24958, 24994, 24546, 25035, 24701, 24244, 25136, 24637, 24362, 25516, 24194, 24341, 26020, 22740, 25504, 27982, 12539, -15362, -32970, -28627, -28660, -30971, -28925, -29724, -30146, -29110, -29719, -29600, -29002, -29627, -29455, -29198, -29731, -29155, -28985, -29625, -28858, -28997, -29675, -28472, -29215, -29851, -27856, -30107, -31446, -20868, 10080, 28739, 25226, 24900, 25392, 25085, 25224, 25201, 25124, 25177, 24981, 24854, 24944, 24880, 24959, 25065, 24807, 24900, 25024, 24665, 24894, 24893, 24291, 24825, 24742, 24013, 25055, 24545, 23688, 25661, 23635, 23484, 28184, 20522, -4034, -30022, -30918, -27962, -30795, -29484, -29168, -29917, -29236, -29337, -29608, -29229, -29362, -29494, -29356, -29462, -29436, -29307, -29376, -29334, -29252, -29286, -29250, -29179, -29145, -29118, -29052, -28988, -29017, -28932, -28856, -28955, -28755, -28681, -28972, -28758, -25113, -18027, -11494, -6334, -2134, 1752, 4798, 7056, 10156, 18145, 24901, 25941, 25393, 25206, 25529, 25330, 25308, 25436, 25279, 25311, 25366, 25248, 25298, 25326, 25247, 25279, 25266, 25208, 25240, 25215, 25177, 25205, 25167, 25137, 25160, 25094, 25061, 25065, 24971, 24963, 24995, 24911, 24967, 24973, 24828, 24984, 25134, 23826, 19168, 13776, 9361, 5595, 2462, -150, -2366, -4121, -5477, -6464, -6972, -7095, -6849, -6119, -5103, -3765, -2004, -129, 2004, 4486, 6828, 9385, 12210, 14746, 17488, 20466, 22992, 24581, 24802, 24059, 24482, 24665, 23795, 24722, 24561, 23393, 25385, 23909, 22902, 28305, 20580, -3804, -29391, -31929, -28137, -30848, -29948, -29449, -30482, -29742, -29726, -30181, -29668, -29798, -30037, -29761, -29927, -29940, -29664, -29849, -29788, -29565, -29764, -29610, -29431, -29641, -29335, -29195, -29509, -29210, -29349, -29735, -29045, -29425, -29861, -27891, -24097, -20176, -12120};