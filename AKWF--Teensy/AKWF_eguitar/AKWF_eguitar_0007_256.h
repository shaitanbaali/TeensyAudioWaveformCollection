/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eguitar_0007 256 samples */
 
const int16_t AKWF_eguitar_0007_256_DATA [256] = 
{1180, 3296, 5521, 8114, 11183, 14717, 18867, 24001, 30404, 32936, 32609, 32615, 32563, 32507, 32442, 32374, 32310, 32241, 32181, 32122, 32066, 32016, 31955, 31880, 31798, 31724, 31649, 31573, 31498, 31416, 31345, 31266, 31191, 31115, 31039, 30974, 30895, 30818, 30735, 30669, 30594, 30515, 30440, 30366, 30294, 30218, 30143, 30070, 29994, 29925, 29849, 29777, 29710, 29629, 29557, 29484, 29413, 29341, 29267, 29195, 29123, 29053, 28976, 28909, 28834, 28766, 28696, 28624, 28557, 28498, 28412, 28341, 28272, 28205, 28135, 28066, 27987, 27917, 27845, 27768, 27695, 27622, 27555, 27484, 27408, 27338, 27264, 27186, 27133, 26621, 25614, 24609, 23608, 22589, 21613, 20657, 19733, 18817, 17939, 17080, 16183, 15347, 14545, 13730, 12937, 12135, 11330, 10569, 9850, 9153, 8493, 7866, 7252, 6721, 6185, 5660, 5130, 4560, 3925, 3188, 2421, 1662, 886, 34, -770, -1505, -2110, -2591, -3001, -3352, -3695, -4106, -4519, -4924, -5502, -6246, -6962, -7718, -8797, -10262, -11988, -14053, -17275, -22182, -29112, -32809, -32504, -32485, -32434, -32385, -32308, -32234, -32162, -32097, -32033, -31964, -31906, -31858, -31805, -31733, -31651, -31580, -31504, -31433, -31353, -31278, -31203, -31122, -31051, -30974, -30902, -30826, -30747, -30677, -30599, -30528, -30452, -30380, -30314, -30234, -30160, -30080, -30018, -29939, -29865, -29790, -29720, -29648, -29572, -29502, -29429, -29357, -29288, -29214, -29145, -29078, -28998, -28930, -28856, -28788, -28717, -28645, -28576, -28508, -28436, -28362, -28297, -28224, -28158, -28089, -28013, -27950, -27884, -27798, -27729, -27659, -27588, -27516, -27446, -27369, -27299, -27221, -27162, -26699, -25842, -25014, -24146, -23284, -22424, -21547, -20649, -19765, -18885, -18034, -17216, -16414, -15637, -14845, -14041, -13188, -12381, -11639, -10904, -10143, -9383, -8629, -7850, -7007, -6175, -5354, -4478, -3641, -2839, -2022, -1185, -340};