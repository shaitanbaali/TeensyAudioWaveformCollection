/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eguitar_0008 256 samples */
 
const int16_t AKWF_eguitar_0008_256_DATA [256] = 
{1221, 3481, 5341, 6851, 7776, 8351, 9250, 10157, 10533, 11033, 11440, 11624, 11997, 12385, 13497, 15956, 19157, 22608, 26367, 30392, 31946, 31753, 31718, 31656, 31584, 31510, 31431, 31370, 31299, 31229, 31158, 31105, 31041, 30965, 30885, 30808, 30733, 30652, 30575, 30497, 30421, 30345, 30265, 30193, 30115, 30032, 29957, 29880, 29806, 29727, 29653, 29575, 29502, 29421, 29349, 29271, 29198, 29125, 29045, 28980, 28912, 28822, 28749, 28677, 28603, 28530, 28454, 28377, 28309, 28231, 28157, 28082, 28013, 27945, 27869, 27797, 27727, 27655, 27583, 27508, 27440, 27371, 27301, 27224, 27152, 27076, 27000, 26928, 26856, 26784, 26706, 26638, 26562, 26489, 26411, 26351, 25863, 24920, 23999, 23051, 22175, 21273, 20324, 19514, 18726, 18004, 17325, 16535, 15633, 14614, 13343, 11995, 10684, 9445, 8095, 6748, 5740, 4807, 4087, 3778, 3794, 3915, 4051, 4003, 3944, 3933, 3648, 3197, 2599, 1664, 349, -1077, -2617, -4234, -5950, -8269, -11367, -14770, -17393, -19800, -22191, -24112, -26263, -29017, -32007, -32847, -32659, -32612, -32522, -32441, -32369, -32302, -32248, -32212, -32164, -32098, -32014, -31923, -31771, -32008, -27867, -19838, -14817, -12482, -13528, -18243, -26180, -31371, -31247, -31191, -31146, -31090, -31016, -30920, -30811, -30716, -30632, -30562, -30511, -30465, -30409, -30336, -30253, -30180, -30103, -30031, -29955, -29882, -29806, -29734, -29656, -29582, -29509, -29434, -29365, -29290, -29218, -29157, -29069, -28995, -28925, -28853, -28780, -28709, -28630, -28563, -28489, -28416, -28337, -28261, -28189, -28113, -28036, -27969, -27897, -27828, -27755, -27685, -27604, -27538, -27424, -26185, -24342, -22768, -21655, -21033, -20845, -20903, -20955, -20880, -20748, -20373, -19631, -18672, -17482, -16141, -14698, -13260, -11970, -10817, -9720, -8693, -7796, -6877, -6060, -5281, -4533, -3798, -3122, -2641, -2510, -2496, -2278, -1971, -1438, -490};