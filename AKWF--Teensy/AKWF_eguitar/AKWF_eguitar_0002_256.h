/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eguitar_0002 256 samples */
 
const int16_t AKWF_eguitar_0002_256_DATA [256] = 
{2709, 7956, 13899, 20240, 27263, 32401, 32555, 32466, 32461, 32432, 32399, 32363, 32312, 32261, 32213, 32172, 32131, 32085, 32046, 32012, 31979, 31944, 31920, 31871, 31807, 31756, 31694, 31641, 31581, 31519, 31461, 31404, 31341, 31278, 31224, 31165, 31103, 31052, 30990, 30925, 30874, 30815, 30752, 30694, 30641, 30578, 30523, 30473, 30415, 30351, 30294, 30229, 30175, 30128, 30061, 30004, 29950, 29887, 29834, 29778, 29722, 29660, 29606, 29550, 29492, 29438, 29383, 29326, 29270, 29220, 29162, 29100, 29045, 28992, 28931, 28877, 28826, 28768, 28716, 28659, 28602, 28551, 28494, 28435, 28383, 28330, 28269, 28221, 28170, 28116, 28059, 28007, 27969, 27900, 27842, 27789, 27735, 27686, 27631, 27577, 27524, 27461, 27395, 27338, 27277, 27210, 27144, 27076, 27008, 26942, 26874, 26801, 26721, 26644, 26564, 26487, 26433, 26382, 25217, 23289, 21233, 19015, 16504, 13607, 10330, 6738, 2828, -1627, -6745, -12170, -17840, -23607, -29545, -32546, -32280, -32287, -32255, -32225, -32191, -32151, -32101, -32061, -32021, -31977, -31928, -31890, -31845, -31815, -31787, -31744, -31710, -31655, -31594, -31539, -31481, -31421, -31359, -31303, -31244, -31183, -31127, -31069, -31008, -30949, -30897, -30837, -30772, -30715, -30657, -30594, -30542, -30484, -30421, -30366, -30307, -30250, -30195, -30134, -30072, -30019, -29962, -29899, -29850, -29792, -29734, -29674, -29623, -29581, -29505, -29448, -29389, -29336, -29282, -29225, -29167, -29112, -29053, -28994, -28945, -28886, -28827, -28772, -28715, -28658, -28607, -28557, -28498, -28440, -28387, -28336, -28279, -28224, -28172, -28111, -28060, -28008, -27953, -27903, -27846, -27792, -27738, -27685, -27627, -27572, -27522, -27467, -27415, -27362, -27301, -27241, -27188, -27126, -27062, -27004, -26940, -26873, -26817, -26751, -26675, -26602, -26523, -26438, -26366, -26275, -26261, -25893, -24526, -23077, -21525, -19725, -17628, -15258, -12656, -9588, -5984, -1464};