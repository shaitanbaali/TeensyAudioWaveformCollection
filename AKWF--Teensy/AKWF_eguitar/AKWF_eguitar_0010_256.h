/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eguitar_0010 256 samples */
 
const int16_t AKWF_eguitar_0010_256_DATA [256] = 
{2462, 9959, 17397, 24034, 29003, 31638, 31819, 30325, 28293, 26849, 26516, 27014, 27920, 28716, 28970, 28712, 28179, 27605, 27231, 27206, 27461, 27847, 28184, 28316, 28207, 27935, 27627, 27413, 27376, 27503, 27711, 27901, 27983, 27924, 27764, 27575, 27435, 27403, 27478, 27611, 27747, 27826, 27820, 27750, 27651, 27571, 27543, 27571, 27631, 27693, 27723, 27703, 27641, 27559, 27488, 27454, 27462, 27497, 27540, 27562, 27551, 27508, 27449, 27395, 27362, 27360, 27376, 27401, 27416, 27407, 27378, 27337, 27295, 27267, 27254, 27254, 27261, 27264, 27258, 27241, 27218, 27193, 27168, 27145, 27124, 27106, 27088, 27074, 27061, 27053, 27042, 27026, 27001, 26966, 26928, 26894, 26869, 26858, 26857, 26857, 26846, 26813, 26760, 26697, 26646, 26620, 26636, 26686, 26739, 26766, 26739, 26638, 26503, 26393, 26373, 26474, 26665, 26859, 26952, 26855, 26561, 26064, 25319, 24302, 22982, 21355, 19526, 17627, 15789, 14037, 12324, 10644, 8942, 7230, 5587, 3779, 1433, -1775, -6042, -11166, -16546, -21492, -25459, -28442, -30540, -31890, -32633, -32794, -32566, -31937, -31302, -30935, -30948, -31237, -31623, -31900, -31932, -31773, -31520, -31278, -31156, -31187, -31327, -31499, -31626, -31642, -31551, -31402, -31255, -31171, -31181, -31262, -31370, -31453, -31467, -31410, -31310, -31206, -31144, -31148, -31207, -31290, -31359, -31381, -31347, -31277, -31197, -31140, -31125, -31148, -31188, -31225, -31230, -31194, -31132, -31063, -31010, -30992, -31009, -31045, -31076, -31083, -31054, -30994, -30928, -30874, -30855, -30874, -30912, -30945, -30943, -30890, -30794, -30681, -30586, -30537, -30546, -30593, -30647, -30673, -30648, -30575, -30482, -30401, -30363, -30381, -30438, -30505, -30543, -30525, -30451, -30348, -30254, -30205, -30223, -30296, -30380, -30433, -30412, -30289, -30114, -29982, -29979, -30120, -30326, -30530, -30652, -30605, -30442, -29965, -28733, -26324, -22496, -17384, -11278, -4351};