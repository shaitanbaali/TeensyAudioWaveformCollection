/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eguitar_0021 256 samples */
 
const int16_t AKWF_eguitar_0021_256_DATA [256] = 
{5061, 20025, 29437, 32904, 32246, 31247, 31864, 32177, 31701, 31589, 31910, 31953, 31738, 31749, 31922, 31900, 31775, 31810, 31910, 31890, 31831, 31851, 31877, 31828, 31778, 31786, 31777, 31705, 31642, 31625, 31591, 31520, 31460, 31424, 31393, 31363, 31335, 31309, 31271, 31249, 31191, 31174, 31639, 30921, 26474, 19548, 12295, 4836, -2632, -10781, -20164, -27346, -29905, -30034, -29400, -29028, -29513, -29575, -28915, -29096, -29924, -29770, -27107, -18848, -6764, 3099, 9915, 14545, 17284, 18885, 19810, 20450, 21365, 22960, 25329, 28423, 30831, 31518, 31422, 31269, 31173, 31251, 31288, 31198, 31145, 31160, 31141, 31081, 31058, 31067, 31046, 31005, 30993, 30996, 30975, 30939, 30911, 30877, 30820, 30758, 30706, 30649, 30579, 30509, 30450, 30411, 30396, 30369, 30318, 30291, 30297, 30254, 30174, 30188, 30236, 30226, 29793, 28229, 25866, 23569, 21465, 19577, 17911, 16420, 15093, 13903, 12769, 11611, 10362, 8952, 7321, 5354, 2914, -200, -4088, -8883, -15959, -24400, -29706, -31227, -31190, -30564, -30455, -30827, -30776, -30518, -30573, -30723, -30632, -30499, -30567, -30651, -30572, -30503, -30575, -30622, -30553, -30509, -30547, -30548, -30481, -30460, -30497, -30481, -30413, -30399, -30425, -30377, -30292, -30291, -30323, -30259, -30175, -30206, -30244, -30136, -30045, -30147, -30185, -29939, -29913, -30291, -30254, -29204, -26451, -21987, -17619, -14077, -10765, -7616, -4868, -2478, -371, 1431, 2864, 3933, 4679, 5114, 5235, 5069, 4650, 4000, 3133, 2082, 885, -453, -1927, -3541, -5288, -7101, -8939, -10828, -12794, -14749, -16677, -18634, -20574, -22395, -24138, -25982, -27717, -28935, -29577, -29681, -29524, -29497, -29534, -29511, -29478, -29463, -29455, -29444, -29423, -29390, -29371, -29373, -29339, -29257, -29200, -29175, -29092, -28966, -28937, -28976, -28906, -28786, -28804, -28884, -28766, -28681, -29024, -28665, -26104, -22309, -18439, -9858};