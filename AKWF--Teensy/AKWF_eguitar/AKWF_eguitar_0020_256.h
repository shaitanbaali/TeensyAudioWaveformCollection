/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eguitar_0020 256 samples */
 
const int16_t AKWF_eguitar_0020_256_DATA [256] = 
{2084, 6508, 7862, 9558, 13313, 18840, 25268, 28357, 27371, 26647, 27141, 27264, 27008, 26982, 27123, 27120, 27028, 27018, 27047, 27046, 27022, 26984, 26965, 27005, 27019, 26941, 26891, 26949, 26956, 26838, 26800, 26900, 26884, 26712, 26704, 26863, 26801, 26568, 26637, 26889, 26757, 26465, 26651, 26955, 26613, 26213, 26644, 27058, 26447, 26017, 26888, 27256, 25880, 25709, 27646, 28493, 25585, 10535, -15494, -30789, -30528, -29062, -29615, -29780, -29783, -29722, -29629, -29661, -29734, -29667, -29559, -29580, -29630, -29589, -29527, -29507, -29555, -29688, -29744, -29632, -29568, -29642, -29649, -29532, -29481, -29530, -29522, -29497, -29221, -28871, -31371, -30639, -12350, 13826, 26906, 29182, 27917, 25847, 26493, 27812, 27083, 26287, 26916, 27413, 26826, 26476, 26951, 27148, 26717, 26595, 26951, 27011, 26709, 26627, 26778, 26754, 26597, 26566, 26626, 26660, 26632, 26473, 26374, 26629, 26783, 25793, 26147, 29759, 23787, 517, -21491, -30958, -32671, -29899, -28322, -30238, -30862, -29469, -29251, -30251, -30251, -29473, -29522, -30070, -29937, -29457, -29374, -29502, -29507, -29450, -29380, -29414, -29669, -29758, -29393, -29265, -29740, -29750, -28943, -29033, -29912, -31105, -29567, -13171, 13951, 28365, 28754, 27363, 26492, 26602, 27431, 27181, 26556, 26849, 27310, 26949, 26549, 26887, 27176, 26787, 26555, 26961, 27103, 26590, 26416, 26861, 26827, 26174, 26173, 26821, 26642, 25849, 26143, 27028, 26469, 25397, 26262, 27485, 25832, 24465, 27454, 29201, 24433, 10326, -14360, -31798, -32081, -28981, -29757, -30517, -29898, -29625, -29954, -30072, -29853, -29745, -29769, -29686, -29533, -29505, -29568, -29604, -29613, -29624, -29619, -29579, -29537, -29524, -29517, -29489, -29458, -29432, -29411, -29393, -29356, -29291, -29255, -29259, -29216, -29122, -29110, -29160, -29092, -28949, -28992, -29108, -28854, -28616, -29224, -29409, -27411, -23379, -17697, -11995, -7927, -3542};