/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eguitar_0012 256 samples */
 
const int16_t AKWF_eguitar_0012_256_DATA [256] = 
{851, 5928, 13530, 20648, 27530, 31771, 32397, 32252, 32245, 32242, 32225, 32204, 32182, 32159, 32141, 32124, 32088, 32048, 32018, 31987, 31949, 31920, 31891, 31856, 31828, 31798, 31777, 31755, 31730, 31719, 31694, 31678, 31661, 31650, 31632, 31618, 31604, 31572, 31551, 31487, 31500, 31371, 30185, 28164, 26414, 25139, 24251, 23729, 23544, 23655, 24066, 24740, 25654, 26774, 28059, 29530, 30670, 30954, 30863, 30842, 30806, 30776, 30740, 30707, 30672, 30640, 30610, 30580, 30546, 30504, 30469, 30426, 30393, 30356, 30312, 30267, 30222, 30185, 30149, 30114, 30073, 30037, 30005, 29974, 29942, 29909, 29874, 29853, 29818, 29783, 29741, 29694, 29649, 29602, 29553, 29496, 29436, 29372, 29307, 29245, 29177, 29114, 29077, 29042, 29003, 28971, 28940, 28913, 28885, 28839, 28803, 28772, 28730, 28690, 28647, 28600, 28555, 28499, 28446, 28386, 28366, 27877, 26306, 23901, 20961, 17260, 12773, 7283, 789, -6707, -14692, -23049, -30137, -32748, -32676, -32702, -32679, -32646, -32640, -32603, -32604, -32575, -32570, -32540, -32509, -32480, -32449, -32417, -32385, -32355, -32319, -32293, -32259, -32226, -32194, -32165, -32147, -32121, -32094, -32080, -32063, -32060, -32046, -32040, -32011, -31995, -31954, -30854, -28448, -26038, -24225, -22846, -21902, -21365, -21217, -21416, -21935, -22776, -23877, -25213, -26754, -28501, -30317, -31334, -31416, -31331, -31319, -31272, -31243, -31208, -31185, -31145, -31113, -31080, -31047, -31018, -30981, -30948, -30903, -30854, -30808, -30765, -30717, -30671, -30634, -30602, -30571, -30535, -30496, -30459, -30430, -30402, -30369, -30337, -30307, -30275, -30241, -30202, -30161, -30115, -30063, -30008, -29955, -29895, -29830, -29761, -29691, -29621, -29563, -29525, -29490, -29456, -29419, -29381, -29349, -29319, -29285, -29249, -29209, -29173, -29130, -29089, -29040, -28989, -28942, -28886, -28828, -28757, -28737, -27963, -25852, -22777, -19039, -14519, -8697, -1768};