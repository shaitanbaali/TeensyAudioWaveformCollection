/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eguitar_0015 256 samples */
 
const int16_t AKWF_eguitar_0015_256_DATA [256] = 
{5632, 21869, 31912, 31337, 31326, 31268, 31256, 31213, 31179, 31178, 31124, 31072, 31019, 30965, 30930, 30892, 30870, 30825, 30772, 30710, 30650, 30616, 30581, 30619, 30700, 26138, 19461, 14391, 10370, 7487, 5716, 4994, 5284, 6365, 8171, 10533, 13316, 16383, 19620, 22913, 26209, 29286, 30287, 30084, 30042, 29968, 29902, 29869, 29826, 29765, 29699, 29641, 29585, 29520, 29466, 29409, 29358, 29308, 29214, 29277, 28677, 25767, 22096, 18014, 13223, 7130, -441, -9158, -18779, -29148, -33036, -32550, -32599, -32557, -32524, -32480, -32447, -32422, -32368, -32318, -32276, -32233, -32189, -32166, -32151, -32130, -32118, -32098, -32107, -32085, -31971, -32249, -30965, -23667, -15729, -8959, -2869, 2457, 7069, 11128, 14701, 17604, 19763, 20841, 20605, 18950, 15527, 10222, 3340, -4745, -13718, -24040, -31514, -31841, -31653, -31675, -31644, -31583, -31542, -31502, -31446, -31388, -31319, -31266, -31202, -31151, -31069, -30984, -30890, -30787, -30776, -30651, -31032, -27750, -17516, -2937, 19867, 31758, 30572, 30735, 30665, 30637, 30639, 30622, 30669, 30636, 30592, 30555, 30513, 30474, 30393, 30327, 30246, 30195, 30133, 29917, 30521, 26821, 15439, 5314, -3374, -10847, -17236, -22462, -26909, -30611, -31433, -31261, -31292, -31267, -31247, -31211, -31184, -31152, -31106, -31054, -30920, -30817, -30762, -30689, -30666, -30498, -31704, -19245, 10719, 30353, 30964, 30573, 30655, 30649, 30554, 30612, 30642, 30638, 30611, 30550, 30520, 30391, 30260, 30223, 30161, 30140, 29818, 30918, 23140, -7868, -31454, -31548, -31151, -31206, -31183, -31129, -31139, -31206, -31230, -31201, -31177, -31167, -31139, -31095, -31048, -30972, -30949, -30877, -30709, -31013, -29883, -18846, -6050, 4011, 12359, 18761, 23012, 25240, 25610, 24346, 21713, 17998, 13390, 8122, 2378, -3560, -9604, -15493, -21048, -26224, -30197, -30846, -30627, -30600, -30517, -30343, -30620, -28724, -19845, -6418};