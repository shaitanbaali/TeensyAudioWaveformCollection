/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eguitar_0014 256 samples */
 
const int16_t AKWF_eguitar_0014_256_DATA [256] = 
{25971, 26396, 25750, 25750, 25757, 25716, 25517, 25656, 25656, 25649, 25649, 25611, 25612, 25545, 25507, 25435, 25402, 25343, 25212, 25395, 24714, 17755, 10265, 5185, 1301, -1651, -3794, -4463, -5949, -23486, -30793, -29352, -29713, -29617, -29593, -29583, -29517, -29566, -29503, -29485, -29424, -29398, -29359, -29210, -29145, -29066, -29148, -29048, -28800, -29591, -26388, 10090, 28820, 25206, 25855, 25742, 25760, 25716, 25688, 25810, 25759, 25843, 25939, 25886, 25865, 25811, 25773, 25700, 25615, 25549, 25462, 25368, 25623, 24330, 16106, 5554, -9038, -26637, -30069, -29110, -29493, -29198, -28948, -30670, -23834, 17421, 27853, 24818, 25485, 25599, 25318, 25480, 25383, 25484, 25500, 25386, 25425, 25332, 25261, 25204, 25050, 24949, 24790, 24745, 24773, 24640, 24525, 24937, 22582, -8273, -31561, -29883, -30124, -30092, -30013, -29936, -29933, -30002, -29994, -29949, -29902, -29866, -29836, -29768, -29707, -29634, -29593, -29532, -29431, -29512, -29224, -21843, -12712, -6628, -2193, 638, 1508, 13681, 26114, 25385, 25427, 25440, 25422, 25397, 25373, 25380, 25372, 25331, 25301, 25261, 25239, 25113, 24999, 24958, 25100, 25198, 24911, 25714, 22741, -12047, -32449, -29348, -29932, -29755, -29814, -29737, -29727, -29814, -29775, -29780, -29492, -29596, -29399, -29432, -29553, -28377, -32507, -14127, 25849, 26130, 25602, 25609, 25604, 25393, 25306, 25414, 25443, 25429, 25407, 25382, 25377, 25347, 25341, 25285, 25259, 25194, 25148, 24970, 24698, 25195, 22367, 13325, 5371, -1049, -6176, -9973, -12409, -13432, -13184, -11729, -9276, -6101, -2235, 1842, 6458, 11162, 15824, 20724, 23696, 27530, 9993, -28620, -30503, -29971, -30149, -30192, -30116, -30169, -30184, -30291, -30261, -30233, -30127, -29907, -29855, -29786, -29695, -29653, -29571, -29451, -29560, -29090, -23026, -16339, -12277, -9685, -8277, -7875, -8225, -9366, -11402, -14215, -17528, -20984, -27148, -24730};