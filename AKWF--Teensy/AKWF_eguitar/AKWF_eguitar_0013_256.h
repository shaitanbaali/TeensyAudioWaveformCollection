/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eguitar_0013 256 samples */
 
const int16_t AKWF_eguitar_0013_256_DATA [256] = 
{16208, 27141, 26536, 26187, 26458, 26251, 26400, 26234, 26340, 26282, 26365, 26403, 26380, 26389, 26347, 26357, 26318, 26297, 26262, 26210, 26182, 26138, 26089, 26067, 25960, 26243, 24433, 18614, 11156, 4669, -1063, -5703, -9415, -12166, -14029, -15056, -15311, -14937, -13967, -12485, -10503, -8082, -5294, -2147, 1273, 4893, 8622, 12434, 16224, 20038, 23673, 25893, 26209, 26102, 26110, 26095, 26076, 26062, 26024, 25985, 25936, 25893, 25841, 25794, 25750, 25710, 25674, 25639, 25611, 25581, 25555, 25534, 25513, 25493, 25475, 25457, 25438, 25426, 25414, 25402, 25389, 25369, 25352, 25322, 25296, 25268, 25238, 25204, 25173, 25146, 25118, 25090, 25054, 25024, 24997, 24968, 24938, 24907, 24875, 24851, 24818, 24789, 24760, 24725, 24696, 24668, 24640, 24611, 24578, 24546, 24519, 24494, 24465, 24429, 24393, 24339, 24269, 24175, 24079, 24038, 24028, 23978, 23947, 23921, 23892, 23860, 23835, 23808, 23776, 23756, 23718, 23701, 23665, 23638, 23618, 23559, 23548, 23473, 23422, 23313, 23286, 23268, 23177, 23257, 23129, 22090, 17728, 12141, 184, -18943, -31490, -32593, -32402, -32414, -32436, -32472, -32408, -32493, -32435, -32493, -32468, -32491, -32502, -32499, -32523, -32496, -32501, -32487, -32479, -32483, -32466, -32463, -32466, -32439, -32451, -32391, -32548, -30951, -25971, -19833, -15028, -11127, -8348, -6480, -5544, -5445, -6036, -7284, -9045, -11320, -14036, -17158, -20615, -24309, -28274, -31539, -32544, -32511, -32512, -32518, -32501, -32498, -32487, -32492, -32474, -32470, -32459, -32457, -32454, -32433, -32406, -32348, -32289, -32235, -32187, -32141, -32096, -32059, -32029, -32004, -31972, -31938, -31895, -31831, -31725, -31619, -31587, -31567, -31530, -31496, -31458, -31421, -31387, -31343, -31310, -31275, -31242, -31202, -31166, -31132, -31092, -31063, -31018, -30986, -30918, -30827, -30726, -30668, -30658, -30588, -30604, -30458, -30669, -29803, -25579, -9642};