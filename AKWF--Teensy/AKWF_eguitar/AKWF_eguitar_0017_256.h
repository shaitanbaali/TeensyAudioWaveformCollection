/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eguitar_0017 256 samples */
 
const int16_t AKWF_eguitar_0017_256_DATA [256] = 
{20199, 32079, 26591, 29242, 27587, 28349, 27834, 27886, 28024, 27694, 28133, 27829, 28075, 27763, 27828, 27744, 27703, 27729, 27617, 27672, 27563, 27569, 27495, 27449, 27422, 27364, 27331, 27302, 27202, 27252, 27376, 23865, 17241, 11510, 6735, 2357, -725, -3718, -4987, -6548, -5989, -6288, -3950, -3050, -17167, -31692, -30540, -30373, -30571, -30334, -30589, -30233, -30521, -30177, -30433, -30239, -30375, -30246, -30215, -30276, -30055, -30254, -29718, -30196, -29658, -30119, -29797, -29839, -30049, -29127, -32821, -21121, 16515, 31207, 27168, 28076, 27757, 27846, 27831, 27716, 27816, 27674, 27808, 27860, 27746, 27864, 27617, 27870, 27532, 27788, 27358, 27450, 27507, 27076, 27857, 26523, 28343, 25425, 30273, 23624, -10427, -32910, -29108, -30986, -29974, -30340, -30299, -30051, -30347, -29970, -30316, -30160, -30274, -30161, -30141, -30138, -30052, -30067, -30002, -29904, -29939, -29749, -29869, -29606, -29700, -29585, -29431, -30154, -26174, -17525, -8159, -3195, 3393, 18792, 29866, 27839, 28244, 28044, 28041, 27989, 27939, 28025, 27912, 27998, 27944, 27975, 27897, 27896, 27858, 27817, 27813, 27745, 27760, 27667, 27662, 27581, 27550, 27513, 27443, 27409, 27283, 27391, 27541, 25735, 19000, 13038, 7538, 3796, 874, -16911, -31476, -30559, -29948, -30595, -29996, -30554, -30020, -30437, -30077, -30311, -30212, -30221, -30227, -30081, -30224, -29968, -30178, -29874, -30045, -29728, -29750, -29798, -29497, -29962, -29131, -30259, -28807, -25424, -16284, 8817, 29998, 27898, 27974, 27941, 27982, 27956, 27883, 27925, 27863, 27957, 27918, 28002, 27857, 27925, 27834, 27815, 27829, 27694, 27819, 27373, 27699, 27272, 27595, 27357, 27428, 27788, 26689, 29758, 23062, -14815, -33597, -29775, -30091, -30325, -30065, -30260, -30053, -30131, -30066, -30086, -30216, -30119, -30106, -30088, -30014, -29960, -29744, -29842, -29694, -29694, -29786, -29368, -29990, -28570, -32607, -13733};