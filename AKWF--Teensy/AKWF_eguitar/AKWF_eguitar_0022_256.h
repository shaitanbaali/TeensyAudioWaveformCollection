/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eguitar_0022 256 samples */
 
const int16_t AKWF_eguitar_0022_256_DATA [256] = 
{4037, 19763, 30169, 29496, 29552, 29536, 29518, 29519, 29488, 29431, 29390, 29346, 29300, 29255, 29216, 29172, 29141, 29119, 29113, 29130, 29092, 29035, 28983, 28929, 28871, 28818, 28768, 28709, 28659, 28608, 28551, 28496, 28445, 28391, 28335, 28285, 28228, 28175, 28129, 28079, 28022, 27969, 27910, 27855, 27812, 27757, 27700, 27650, 27594, 27542, 27493, 27440, 27386, 27333, 27282, 27229, 27177, 27127, 27077, 27022, 26973, 26926, 26868, 26812, 26767, 26711, 26661, 26614, 26560, 26510, 26459, 26404, 26358, 26309, 26254, 26205, 26155, 26101, 26054, 26007, 25956, 25904, 25856, 25820, 25763, 25704, 25657, 25605, 25560, 25511, 25462, 25413, 25362, 25308, 25264, 25215, 25165, 25115, 25066, 25015, 24970, 24924, 24878, 24827, 24777, 24727, 24677, 24623, 24573, 24519, 24468, 24422, 24368, 24322, 24269, 24214, 24156, 24099, 24036, 23963, 23943, 23595, 22655, 21721, 20786, 19874, 19003, 18119, 17218, 16330, 15414, 14410, 13157, 11234, 8705, 6046, 3311, 347, -3115, -7578, -13513, -24735, -32970, -32484, -32550, -32570, -32571, -32568, -32567, -32565, -32567, -32575, -32578, -32577, -32586, -32598, -32603, -32612, -32637, -32677, -32685, -32680, -32671, -32662, -32657, -32647, -32640, -32634, -32621, -32612, -32607, -32596, -32586, -32586, -32575, -32566, -32550, -32510, -32450, -32371, -32311, -32247, -32188, -32129, -32066, -32005, -31944, -31877, -31818, -31763, -31697, -31632, -31571, -31508, -31449, -31392, -31336, -31272, -31210, -31153, -31093, -31032, -30973, -30910, -30849, -30793, -30731, -30676, -30618, -30555, -30495, -30437, -30377, -30313, -30259, -30200, -30137, -30084, -30027, -29961, -29908, -29851, -29789, -29730, -29677, -29614, -29559, -29510, -29453, -29389, -29329, -29257, -29197, -29141, -29065, -28995, -28927, -28845, -28756, -28638, -28533, -28479, -28426, -28362, -28304, -28232, -28219, -27908, -26379, -24541, -22593, -20323, -17697, -14488, -10222, -3218};