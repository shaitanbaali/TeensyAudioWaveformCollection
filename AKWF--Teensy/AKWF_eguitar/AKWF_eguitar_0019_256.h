/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eguitar_0019 256 samples */
 
const int16_t AKWF_eguitar_0019_256_DATA [256] = 
{3721, 8746, 13249, 17713, 21715, 25196, 28416, 30672, 31026, 30870, 30868, 30821, 30783, 30748, 30692, 30656, 30610, 30583, 30547, 30512, 30487, 30444, 30413, 30375, 30327, 30310, 30270, 30268, 30213, 30218, 30148, 30151, 30210, 29249, 26823, 24076, 20949, 17524, 13716, 9460, 4876, 15, -5088, -10312, -15793, -21025, -26892, -31571, -32745, -32356, -32485, -32402, -32433, -32390, -32382, -32363, -32333, -32323, -32286, -32250, -32218, -32183, -32138, -32059, -32013, -31947, -31900, -31859, -31777, -31784, -31640, -32235, -28498, -19725, -10359, -1351, 8315, 18118, 27724, 31033, 30605, 30500, 30592, 30511, 30576, 30512, 30556, 30518, 30531, 30506, 30476, 30446, 30400, 30390, 30319, 30317, 30202, 30188, 30082, 30047, 29983, 29893, 29935, 29711, 30441, 27906, 18567, 7629, -2267, -12032, -21311, -29833, -32742, -32390, -32336, -32374, -32310, -32366, -32312, -32348, -32306, -32325, -32292, -32254, -32200, -32141, -32091, -32031, -32003, -31932, -31912, -31790, -32107, -29996, -24296, -17945, -12005, -6147, -753, 4521, 9821, 15052, 19801, 23818, 27289, 29839, 30682, 30568, 30546, 30544, 30504, 30496, 30448, 30429, 30390, 30358, 30339, 30252, 30343, 29917, 28242, 26022, 23791, 21200, 18397, 15362, 12288, 9383, 6650, 3988, 1322, -1299, -3940, -6523, -8973, -11352, -13694, -15996, -18072, -19709, -20979, -21974, -22771, -23469, -23950, -24022, -23569, -22588, -21159, -19346, -17260, -15106, -12897, -10611, -8038, -5028, -1872, 1365, 4760, 8138, 11441, 14616, 17504, 20079, 22363, 24345, 26027, 27167, 27738, 27992, 27856, 27125, 25822, 24043, 21835, 19278, 16264, 12742, 8826, 4698, 315, -4280, -8931, -13670, -18517, -23654, -29326, -32599, -32655, -32418, -32480, -32373, -32367, -32309, -32287, -32261, -32225, -32211, -32152, -32131, -32064, -32024, -31970, -31922, -31883, -31838, -31802, -31722, -31790, -31637, -28343, -22970, -17760, -12751, -8198, -2964};