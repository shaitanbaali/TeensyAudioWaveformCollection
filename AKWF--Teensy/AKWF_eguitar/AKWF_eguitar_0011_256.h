/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eguitar_0011 256 samples */
 
const int16_t AKWF_eguitar_0011_256_DATA [256] = 
{8916, 23097, 30820, 30360, 30380, 30370, 30353, 30344, 30320, 30280, 30249, 30219, 30180, 30120, 30065, 30010, 29933, 30205, 25262, 16523, 9615, 4091, 278, -1530, -1454, 397, 3722, 8394, 14101, 20247, 26793, 29986, 29663, 29638, 29554, 29423, 29306, 29233, 29147, 29077, 29012, 28952, 28906, 28857, 28799, 28743, 28668, 28525, 28682, 25995, 19008, 8656, -8949, -29244, -32255, -31503, -31649, -31623, -31637, -31643, -31603, -31568, -31534, -31495, -31437, -31364, -31289, -31115, -31627, -27749, -16882, -8478, -2295, 1594, 3147, 2551, 273, -3171, -7582, -12939, -18710, -24754, -29997, -30958, -30740, -30745, -30709, -30635, -30521, -30343, -30211, -30048, -30296, -27477, -13234, 11868, 31167, 29889, 30007, 29970, 29941, 29994, 30009, 29971, 29947, 29915, 29848, 29761, 29687, 29602, 29499, 29753, 22922, 12393, 5746, 2093, 1047, 2052, 4855, 9253, 14754, 21039, 27509, 29422, 29100, 29131, 29094, 29061, 28978, 28822, 28844, 28721, 28930, 27729, 3758, -28879, -32041, -31285, -31422, -31354, -31379, -31378, -31204, -31112, -31056, -30580, -32642, -14446, 24769, 30188, 28867, 29100, 28888, 28856, 28919, 28885, 28857, 28826, 28802, 28760, 28687, 28611, 28501, 28476, 28383, 19228, 7048, -1550, -7358, -10240, -10487, -8556, -4857, 193, 6171, 12734, 19418, 26056, 28501, 28157, 28196, 28169, 28122, 28037, 27948, 27873, 27796, 27708, 27588, 27470, 27363, 27648, 22886, 11447, -17979, -34114, -32322, -32627, -32616, -32624, -32676, -32672, -32641, -32583, -32524, -32439, -32351, -32281, -32099, -32533, -29907, -19176, -11002, -6627, -5333, -6625, -9850, -14663, -20708, -28087, -32208, -31939, -31928, -31894, -31853, -31809, -31762, -31704, -31608, -31504, -31419, -31348, -31290, -31244, -31203, -31149, -31090, -31017, -30914, -30800, -30694, -30619, -30564, -30512, -30452, -30395, -30343, -30269, -30188, -30103, -29971, -29963, -29458, -24072, -15187, -3554};