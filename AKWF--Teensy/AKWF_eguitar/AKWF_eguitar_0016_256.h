/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eguitar_0016 256 samples */
 
const int16_t AKWF_eguitar_0016_256_DATA [256] = 
{1452, 6886, 13728, 20853, 27771, 30816, 30500, 30537, 30520, 30512, 30496, 30451, 30395, 30340, 30271, 30291, 29949, 27463, 24433, 21769, 19939, 18948, 18499, 18613, 19698, 21928, 24657, 28039, 29912, 29750, 29720, 29674, 29623, 29578, 29522, 29450, 29387, 29322, 29259, 29197, 29147, 29096, 29041, 28993, 28954, 28906, 28856, 28804, 28743, 28688, 28635, 28577, 28526, 28469, 28409, 28357, 28304, 28245, 28196, 28139, 28085, 28030, 27980, 27940, 27867, 27813, 27758, 27705, 27654, 27599, 27545, 27492, 27433, 27380, 27321, 27228, 27110, 26963, 26872, 26831, 26778, 26729, 26675, 26624, 26574, 26523, 26461, 26382, 26279, 26124, 26167, 25551, 19307, 7449, -13110, -31717, -32666, -32345, -32406, -32384, -32406, -32399, -32352, -32317, -32276, -32236, -32173, -32092, -32016, -31961, -31846, -32254, -28574, -20801, -15552, -12249, -10758, -11044, -12899, -16030, -20160, -25062, -30191, -31792, -31508, -31513, -31459, -31420, -31369, -31295, -31204, -31110, -31020, -30942, -30879, -30815, -30755, -30707, -30661, -30616, -30569, -30498, -30427, -30334, -30365, -29516, -27140, -24790, -22483, -20032, -17435, -15122, -13067, -11261, -9822, -8446, -6965, -5631, -4515, -3166, -1936, -933, 215, 1382, 2593, 4031, 5635, 7740, 9879, 11984, 13981, 15739, 17469, 19012, 19853, 20575, 21727, 22914, 24000, 24679, 25053, 25078, 24737, 24426, 24211, 24081, 23649, 22575, 20917, 19296, 17536, 15467, 13216, 10772, 8093, 4932, 1351, -2506, -7039, -12263, -17790, -24077, -29918, -30575, -30370, -30368, -30324, -30289, -30245, -30195, -30149, -30114, -30081, -30041, -30011, -29977, -29941, -29902, -29865, -29781, -29908, -29034, -24376, -20234, -17406, -15655, -14880, -15004, -15849, -17273, -19112, -21224, -23435, -25602, -27651, -29016, -29050, -28967, -28908, -28827, -28729, -28631, -28536, -28454, -28379, -27222, -25337, -23430, -21364, -19136, -16780, -14304, -11618, -8744, -5518, -1523};