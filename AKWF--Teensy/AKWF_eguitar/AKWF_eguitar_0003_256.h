/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eguitar_0003 256 samples */
 
const int16_t AKWF_eguitar_0003_256_DATA [256] = 
{4570, 12089, 17505, 21334, 23786, 25146, 25784, 26052, 25915, 25242, 24258, 23214, 22352, 21872, 21892, 22343, 23045, 23778, 24321, 24504, 24337, 23929, 23402, 22899, 22561, 22484, 22649, 22981, 23379, 23734, 23941, 23941, 23755, 23451, 23111, 22824, 22672, 22689, 22850, 23096, 23356, 23559, 23639, 23578, 23405, 23171, 22934, 22751, 22671, 22701, 22814, 22969, 23121, 23226, 23249, 23193, 23082, 22947, 22821, 22738, 22719, 22757, 22834, 22923, 23000, 23039, 23027, 22972, 22890, 22801, 22724, 22682, 22680, 22707, 22756, 22807, 22844, 22853, 22834, 22790, 22736, 22680, 22636, 22614, 22614, 22630, 22654, 22675, 22686, 22679, 22657, 22624, 22586, 22550, 22520, 22500, 22488, 22483, 22485, 22494, 22511, 22540, 22580, 22621, 22654, 22665, 22642, 22580, 22481, 22370, 22274, 22219, 22224, 22305, 22442, 22594, 22717, 22770, 22720, 22551, 22302, 22042, 21840, 21757, 21844, 22115, 22493, 22867, 23125, 23179, 22904, 22254, 21449, 20765, 20459, 20729, 21791, 23518, 25308, 26486, 26391, 24501, 20661, 15210, 8688, 1732, -5025, -11111, -16625, -21589, -25837, -29251, -31870, -32826, -32737, -32792, -32605, -31610, -30772, -30378, -30347, -30583, -30957, -31321, -31529, -31553, -31472, -31327, -31159, -31015, -30934, -30925, -30968, -31044, -31128, -31195, -31225, -31218, -31185, -31135, -31080, -31034, -31005, -30988, -30982, -30984, -30990, -30997, -31007, -31022, -31038, -31048, -31049, -31037, -31006, -30956, -30896, -30841, -30803, -30794, -30822, -30881, -30956, -31023, -31062, -31056, -30993, -30886, -30763, -30654, -30587, -30586, -30660, -30788, -30932, -31050, -31106, -31072, -30942, -30748, -30543, -30381, -30306, -30353, -30522, -30759, -30997, -31172, -31223, -31109, -30848, -30514, -30194, -29975, -29930, -30104, -30457, -30880, -31267, -31504, -31490, -31081, -30360, -29599, -29060, -28974, -29542, -31096, -32121, -32020, -32031, -31974, -28534, -21629, -13223, -3917};