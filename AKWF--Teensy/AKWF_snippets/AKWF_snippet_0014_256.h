/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0014 256 samples */
 
const int16_t AKWF_snippet_0014_256_DATA [256] = 
{12330, 17504, 17580, 22477, 24754, 23369, 27511, 31193, 23117, 25846, 20093, 15751, 19407, 14670, 15278, 12990, 7655, 9566, 8065, 10802, 10740, 14771, 18427, 19784, 25294, 25233, 22214, 18108, 10373, 5914, 3644, -6067, -13429, -20409, -23034, -26172, -25458, -20186, -17193, -15556, -14856, -12243, -7744, -4813, -2707, -3485, -1927, -1050, -2945, -2135, -1039, 2548, 5560, 8272, 9752, 11392, 9970, 7460, 5217, 5009, -539, -8512, -17616, -22870, -26103, -26852, -27805, -26610, -23351, -20884, -14108, -8232, -4628, 531, 5307, 5043, 7135, 9168, 6070, 2650, 3861, 4244, 8073, 8490, 7514, 7114, 7783, 5063, 4846, 5972, 1518, -4874, -9878, -13800, -16204, -16091, -15713, -16993, -17723, -16090, -13373, -7871, -5516, -509, 1834, 2894, 4268, 2548, 3158, 3903, 1601, 2561, 473, 984, -913, -989, 4059, 7260, 9017, 9887, 9912, 8607, 7325, 8953, 6854, 2683, -2618, -6713, -5024, -4019, -2807, -214, -743, 125, 2263, 6302, 9677, 10449, 13327, 13429, 12518, 14851, 12322, 10130, 10593, 8022, 9216, 8793, 6916, 8095, 6648, 8343, 9766, 7883, 6535, 2150, -649, -1698, -5102, -7069, -8818, -12636, -12032, -9137, -4675, -1155, 1263, 2571, 2280, 6085, 6852, 8095, 5546, 787, 2206, 78, 119, 5070, 2653, 3425, 2762, 1626, 7415, 8861, 13434, 18656, 22523, 25379, 27254, 24754, 21371, 13414, 9660, 5882, -3542, -13724, -22930, -25445, -27315, -26563, -25286, -23281, -23119, -21685, -20958, -16406, -13199, -12225, -12423, -7792, -6744, -6594, -5271, -4041, -1821, 2949, 7031, 9268, 10229, 9951, 9392, 8467, 7202, 2479, -5235, -13233, -20103, -24208, -25734, -28273, -29112, -28350, -25952, -23670, -19958, -17925, -13650, -9407, -7029, -3577, -3039, -4606, -5222, -5327, -2901, 53, 152, 747, 965, 1933, 2714, 5558, 4951, 1464, -582, -2817};