/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0030 256 samples */
 
const int16_t AKWF_snippet_0030_256_DATA [256] = 
{3381, 7958, 11446, 13066, 15977, 17398, 19573, 26074, 32193, 25107, 25488, 28941, 29122, 27640, 26846, 26340, 23993, 23805, 22834, 22086, 22370, 21338, 20570, 20073, 19910, 18203, 15563, 11773, 9210, 7068, 4469, 2762, 1351, 415, -202, -951, -1638, -2667, -2805, -2197, -1781, -1139, 409, 3029, 5274, 8023, 7467, 6639, 4144, 1239, -4452, -12439, -11589, -17115, -23498, -25948, -28041, -28304, -27242, -26675, -25356, -23836, -23025, -22054, -21333, -21310, -2446, 2164, 2821, 3958, 5852, 6793, 8826, 9544, 10504, 10957, 11081, 11218, 10992, 11061, 9995, 10901, 10798, 11044, 10920, 11095, 10735, 10966, 10362, 7529, 6957, 5581, 5491, 4988, 5914, 7729, 8090, 6903, 7500, 7512, 7040, 7223, 6540, 7692, 6457, 7212, 6455, 6259, 5889, 5124, 3663, 3421, 2405, 2247, 1206, 944, -1231, -2299, -2893, -1809, -3104, -3073, -3278, -3717, -3946, -5568, -5538, -5780, -4875, -4144, -5153, -5517, -5658, -4796, -4505, -3768, -3533, -4662, -5219, -5710, -6423, -5916, -6004, -6161, -5642, -5480, -5301, -5675, -5049, -4052, -3365, -3119, -1712, -1985, -5026, -6829, -6805, -5042, -3515, -1816, -1627, -2325, -2798, -1961, 1107, 3425, 1875, 789, 2750, 5316, 4896, 2756, 5146, 5713, 7878, 10187, 10149, 10779, 11360, 10808, 10316, 12265, 12331, 12366, 14213, 13175, 9059, 8503, 8622, 5136, 2317, -4835, -8463, -9747, -11222, -13913, -17163, -17230, -18134, -15819, -15257, -16796, -15122, -18593, -24295, -22702, -19281, -10062, 6075, -6696, -6166, -4748, -6008, -8433, -12298, 6960, 542, 4300, -9033, -20730, 7497, 11117, 8063, 10148, 8220, 7697, 5267, 4292, 3669, 2380, 802, -2282, -2121, -12889, -28536, -26042, -25872, -27403, -25713, -24062, -22703, -21946, -21376, -20562, -19717, -21036, -4504, 8575, -7569, -18610, -16462, -16962, -16101, -11424, -6717, -1426};