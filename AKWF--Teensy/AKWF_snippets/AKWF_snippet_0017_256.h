/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0017 256 samples */
 
const int16_t AKWF_snippet_0017_256_DATA [256] = 
{3930, 12009, 9531, 11223, 17183, 17395, 17155, 21528, 21555, 18151, 22030, 23897, 21080, 19256, 19388, 15446, 13613, 12361, 11549, 12067, 8597, 13100, 19318, 17916, 16572, 18056, 17342, 13149, 15775, 11595, 13750, 15327, 10962, 1385, 5044, 300, -12160, -15832, -17751, -23481, -23847, -22761, -19407, -14838, -13360, -11837, -6898, -8632, -8377, -8028, -7663, -4607, -4375, -105, 5555, 4620, 4280, -253, 2347, -6363, -4456, -1340, -3979, 2891, 12656, 16406, 19819, 24152, 22846, 16882, 18790, 20557, 18799, 21978, 18001, 19308, 18922, 16171, 13198, 8414, 5547, 4197, 6002, 5618, 5598, 10085, 9514, 9286, 3217, 5060, -7246, -16176, -19179, -19996, -21140, -18798, -9040, -13803, -17610, -27546, -27519, -31740, -31679, -26754, -20362, -20059, -21072, -16654, -18342, -10349, -8872, -13552, -6175, -666, -266, 2677, 2034, 7281, 9899, -5842, -7677, -3225, -3189, -10694, -15408, -4272, -1589, -7583, 4283, 13371, 5209, 1699, 7279, 11995, 19556, 21286, 14273, 7599, 13046, 18693, 21825, 21875, 17928, 17959, 16418, 13500, 13059, 10887, 7916, 14119, 18313, 19390, 21548, 20851, 20558, 19084, 18962, 18131, 17804, 16088, 14737, 13749, 13366, 10617, 2986, -7015, -7841, -16298, -24370, -27417, -28285, -26199, -24384, -22512, -21286, -20864, -20789, -17974, -19590, -18583, -17218, -17157, -12476, -11529, -13908, -15452, -16174, -18709, -19201, -17386, -18792, -13004, -9551, -7233, 5185, 7311, 9972, 14714, 16232, 17607, 19740, 20836, 19780, 20450, 18532, 16607, 13659, 11133, 6630, 2267, 293, -1965, -1823, -63, 789, 4828, 6614, 4054, 6005, 6871, 3836, 3441, 3048, 3492, 6755, 2238, -4409, -5778, -10378, -25432, -20858, -19024, -25469, -24426, -24969, -26207, -22122, -20969, -20677, -18317, -18850, -17818, -15817, -15741, -14167, -13287, -14004, -14534, -14792, -16422, -16054, -13910, -12361, -6488, -4886, -5997};