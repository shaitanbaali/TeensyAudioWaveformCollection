/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0046 256 samples */
 
const int16_t AKWF_snippet_0046_256_DATA [256] = 
{6258, 17135, 23027, 22520, 16027, 6583, -2182, -7529, -8853, -7935, -7306, -8607, -11292, -12553, -9700, -1876, 9262, 19898, 25959, 24401, 15027, 630, -14079, -24211, -26865, -22058, -12527, -2444, 4551, 6810, 4750, 752, -2002, -845, 4944, 13735, 21674, 24198, 18623, 5895, -10340, -24567, -31761, -29321, -17924, -1966, 12374, 19580, 17859, 9863, 857, -4398, -3521, 2517, 10162, 15308, 15028, 8795, -1209, -11111, -17508, -19067, -16619, -12102, -7003, -2155, 2490, 7432, 12630, 17338, 19836, 18155, 11155, -19, -12370, -21992, -25884, -22953, -14097, -1905, 9719, 17062, 18167, 13342, 5222, -2380, -6806, -7461, -5478, -2887, -1322, -1329, -2448, -3136, -2218, 466, 4546, 8880, 11680, 11623, 8541, 3248, -2473, -6795, -8917, -8656, -6660, -4345, -2706, -2139, -2448, -2533, -1386, 1268, 5162, 9244, 11867, 11973, 9245, 4171, -1634, -6735, -9725, -9918, -8144, -5585, -3257, -2082, -2049, -2524, -2766, -1677, 1024, 4654, 8178, 10206, 9773, 7185, 3164, -1296, -4761, -6639, -6667, -4886, -2452, -269, 1127, 1299, 631, -82, -252, 545, 2169, 3733, 4279, 3026, -315, -4917, -9166, -11348, -10186, -5486, 1395, 8527, 13801, 15476, 13114, 7647, 682, -5686, -9830, -11442, -10951, -9289, -7466, -5437, -2583, 1628, 7287, 13356, 17743, 18552, 14635, 6262, -4015, -12731, -17271, -16225, -10717, -3982, 659, 1157, -1939, -5626, -6361, -2326, 4816, 15318, 24179, 27298, 22508, 10194, -6062, -21548, -31269, -31885, -23410, -9213, 6016, 17222, 20992, 17129, 7824, -2856, -10758, -13379, -10669, -4495, 2213, 6852, 8344, 6821, 3684, 1056, 114, 952, 2673, 3643, 2831, 221, -3533, -6968, -8498, -7529, -4328, -69, 3285, 4550, 3612, 1111, -1473, -2613, -1685, 1396, 5876, 10098, 12644, 12270, 8088, 571, -8541, -16948, -21986, -21765, -15986, -5507};