/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0044 256 samples */
 
const int16_t AKWF_snippet_0044_256_DATA [256] = 
{2052, 5431, 8098, 10518, 12565, 13246, 13762, 14571, 15543, 18010, 20492, 23645, 26543, 28018, 31111, 32137, 32673, 31033, 31848, 30164, 25751, 25288, 23188, 19925, 16818, 12455, 7929, 2633, -2553, -6227, -7913, -9622, -10426, -10424, -10361, -11493, -12127, -11480, -11069, -9707, -8485, -8728, -10050, -12049, -13753, -14301, -13713, -12522, -11475, -11790, -12930, -13929, -14907, -14972, -14234, -13433, -13661, -15527, -16785, -18465, -19249, -19257, -19434, -18623, -17923, -17594, -16568, -13844, -10230, -6793, -2857, 293, 1395, 1439, 910, 432, -50, 719, 3139, 5885, 8910, 12077, 14056, 15320, 16733, 18434, 20485, 22331, 23515, 24165, 23499, 21450, 19071, 16823, 15208, 13977, 12522, 10341, 7437, 4431, 2245, 1193, 815, 938, 1190, 1478, 1771, 1766, 1789, 1784, 1663, 1258, 452, -325, -1185, -2105, -2848, -3123, -2199, -249, 2136, 4223, 5596, 5956, 5510, 4711, 3878, 3056, 2508, 2611, 2932, 3047, 2950, 2588, 1814, 1045, 480, 86, 84, 154, 61, 576, 1836, 3532, 5500, 7577, 9323, 10702, 11529, 11634, 10933, 9826, 8808, 7780, 6485, 5092, 3586, 1894, 440, -297, -53, 1221, 3180, 5331, 7368, 9273, 11130, 12862, 14303, 15279, 15642, 15065, 13592, 11376, 8524, 5134, 1490, -2085, -5551, -9146, -12570, -15369, -17449, -19024, -20185, -20749, -20918, -20878, -20368, -19481, -18234, -16897, -15648, -14551, -13594, -12736, -11860, -10788, -9539, -8141, -6733, -5574, -4815, -4394, -4262, -4176, -4102, -4194, -4198, -3992, -3706, -3578, -3618, -3865, -4163, -4418, -4355, -3998, -3575, -2973, -2049, -773, 966, 3098, 5457, 7937, 10119, 11659, 11497, 12036, 12361, 10672, 7040, 205, -5663, -10043, -13776, -16515, -20939, -23751, -25983, -28311, -28666, -23033, -23810, -21829, -19199, -15664, -9841, -8087, -5118, -5148, -6925, -6509, -5057, -1540};