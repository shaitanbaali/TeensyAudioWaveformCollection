/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0042 256 samples */
 
const int16_t AKWF_snippet_0042_256_DATA [256] = 
{1830, 2103, 3626, 7806, 9062, 9736, 13588, 17124, 19913, 21923, 21568, 20693, 20406, 20623, 22048, 23799, 23280, 21952, 20955, 18646, 13236, 9450, 7327, 4180, -2653, -7554, -7016, -3066, 1798, 5121, 6378, 7398, 5365, -1770, -11041, -19178, -25916, -30538, -32293, -32226, -32779, -31678, -29927, -27447, -22956, -16403, -8738, -3522, -1369, -365, 322, 954, 863, 497, 1111, 935, 1158, 1761, 1328, 593, 1957, 3961, 6019, 8783, 11850, 14511, 16177, 16672, 17066, 17487, 17674, 16611, 14700, 11171, 6234, 1285, -1144, -1892, -1415, -456, 901, 2494, 2416, 1623, 1109, 582, 1068, 534, -1575, -5583, -9521, -11866, -11916, -11076, -9770, -7878, -5260, -2756, -852, 740, 2985, 4426, 4951, 4804, 3294, 1092, -1566, -4384, -7787, -10575, -11729, -10590, -8114, -5210, -2052, 1263, 4210, 7111, 9664, 11384, 12618, 13110, 12631, 12182, 11620, 10564, 9097, 6796, 4064, 2795, 1808, 379, -1135, -2986, -4952, -5874, -6371, -6312, -5835, -5442, -5071, -5037, -5044, -4970, -5092, -4416, -3075, -2186, -558, 1486, 3025, 3644, 4450, 5554, 5514, 4104, 2315, 562, -731, -1215, -1265, -1065, -1206, -1169, -482, -57, -365, 2366, 2810, 2242, 2734, 2149, 5964, 10488, 1976, -813, -210, -3679, -7579, -12334, -15007, -13500, -12347, -11828, -8883, -3667, -2689, -103, 2680, 6468, 2862, 2215, 9795, 11549, 7730, 2884, -181, -6565, -11406, -13364, -14147, -14044, -11812, -9661, -10435, -10338, -10513, -9872, -1166, -798, -3690, 6814, 16176, 13523, 16244, 21320, 15983, 12146, 12005, 6891, 800, -1159, -4378, -7979, -13118, -16887, -5223, -3802, -3352, 6501, 17701, 21431, 18616, 10369, 9515, 14732, 9411, 4837, 2093, -4474, -11318, -18080, -21887, -20927, -19837, -23579, -19992, -10804, -10814, -14385, -12703, -13935, -14599, -9240, -2653, -358};