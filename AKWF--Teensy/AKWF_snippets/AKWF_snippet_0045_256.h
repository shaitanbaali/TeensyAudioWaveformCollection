/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0045 256 samples */
 
const int16_t AKWF_snippet_0045_256_DATA [256] = 
{9642, 21163, 27868, 30748, 31341, 31666, 30264, 29864, 29241, 27914, 25844, 24695, 23505, 21816, 20285, 19535, 18158, 17475, 17009, 16776, 17153, 16418, 15941, 14872, 13507, 13073, 12813, 11981, 11126, 10858, 10550, 10673, 10692, 10606, 9814, 8885, 8654, 7777, 6659, 5014, 4448, 4476, 3940, 3619, 3355, 2613, 2298, 2330, 1613, 1602, 1349, 1172, -73, -546, -881, -672, -1218, -1725, -2110, -3143, -3651, -4572, -5413, -5471, -5534, -6373, -6654, -6555, -6659, -6640, -7408, -7375, -6175, -6229, -6183, -6707, -6748, -6889, -7439, -7730, -7795, -7551, -7768, -8346, -8966, -10132, -10230, -10111, -10265, -11511, -12589, -12863, -13908, -14588, -14071, -14431, -13895, -14299, -13855, -13814, -14263, -13804, -13978, -13793, -7719, 7672, 21237, 28198, 31277, 32276, 32659, 32530, 32373, 31541, 30451, 28819, 27819, 26639, 25376, 24802, 23382, 22745, 22078, 20398, 19773, 20180, 19202, 18524, 17790, 16766, 15821, 15324, 15093, 14092, 13347, 12639, 11658, 10547, 9622, 8281, 7644, 6650, 5820, 5356, 4871, 4239, 4928, 4848, 3823, 4555, 4379, 4127, 3580, 3729, 3540, 2852, 2948, 1133, 968, 452, -493, -1315, -1525, -1703, -2999, -3911, -4551, -5568, -5678, -5609, -6106, -5743, -5826, -5749, -6633, -7759, -7547, -6393, -6930, -7589, -7860, -8223, -7418, -7406, -7192, -7849, -7845, -7451, -8194, -8819, -11041, -10819, -9959, -10041, -10693, -11875, -12075, -12787, -13788, -14058, -13820, -13210, -13304, -13686, -13485, -13785, -13036, -13563, -13315, -13608, -14102, -13237, -14056, -14791, -14814, -14316, -14085, -13859, -14415, -14704, -14449, -14430, -14238, -13952, -13148, -13243, -13311, -12653, -13549, -13858, -13244, -13272, -13596, -13825, -14175, -14252, -14355, -14274, -15116, -15317, -15996, -16174, -17025, -17234, -18066, -18020, -18622, -19163, -18999, -18089, -18362, -17153, -16381, -17036, -15706, -6160};