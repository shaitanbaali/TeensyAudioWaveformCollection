/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0019 256 samples */
 
const int16_t AKWF_snippet_0019_256_DATA [256] = 
{2432, 10004, 16084, 15258, 13784, 16196, 15606, 8968, 3911, 5706, 8148, 11198, 19226, 23221, 20487, 19644, 19859, 18627, 17465, 16495, 18213, 20170, 19264, 22365, 28048, 25295, 18874, 22561, 31146, 32308, 28755, 23989, 18194, 18944, 23339, 23024, 23148, 23963, 23896, 27971, 30506, 30099, 30197, 21081, 8963, 9677, 13203, 11717, 11844, 11538, 9010, 8320, 8915, 9686, 11968, 13721, 11362, 7910, 7238, 6065, 4836, 6475, 5630, 444, -2505, -1146, 1387, 3024, 3084, 2053, 1854, 2421, 411, -4384, -7814, -7003, -3449, -3600, -7358, -6533, -3397, -3806, -2924, -11026, -15768, -13288, -12838, -12987, -14306, -15479, -16875, -19155, -20909, -21152, -20404, -18677, -15889, -13728, -13170, -12577, -11876, -12658, -14123, -15319, -16300, -16168, -15298, -13840, -10142, -6003, -4047, -2435, -544, -564, -2178, -3905, -5827, -7359, -7634, -7920, -7652, -3979, 1097, 4325, 7407, 10535, 12855, 14350, 12932, 11194, 12123, 10849, 7758, 6905, 6436, 6995, 9293, 11287, 14683, 19038, 23134, 26980, 25993, 22001, 19522, 14984, 10864, 8675, 2589, 1029, 9672, 15747, 17363, 20363, 18497, 11458, 6995, 3111, -2022, -3351, -3003, -4865, -3174, 2148, 2848, 2105, 3826, -604, -8611, -8645, -7044, -10547, -11526, -10426, -11721, -10103, -7094, -9254, -12971, -13180, -9063, -6025, -10826, -15546, -13982, -14981, -17404, -16168, -15687, -15273, -15508, -16408, -10066, -3445, -7071, -12714, -16175, -19203, -18045, -14262, -13926, -17572, -16796, -10324, -11369, -15619, -9365, -5324, -10120, -11811, -12491, -14992, -15704, -16692, -15510, -12873, -14921, -15866, -12626, -12777, -16320, -17170, -13250, -7500, -5650, -7642, -8023, -8828, -14317, -17967, -16248, -15580, -13961, -7119, -1916, -3238, -8748, -12076, -9669, -9144, -13854, -18047, -21519, -19584, -6686, 4521, 4951, 3868, 3970, -3027, -10791, -6947, -3351, -10768, -13205, -4812};