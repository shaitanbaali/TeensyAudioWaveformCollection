/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0022 256 samples */
 
const int16_t AKWF_snippet_0022_256_DATA [256] = 
{3014, 4073, 7466, 8595, 10591, 10906, 12343, 12377, 11223, 10998, 12037, 13320, 15781, 18514, 19097, 19705, 20661, 19930, 16832, 14612, 12400, 8131, 3785, 2518, 827, -1229, -1778, -2960, -2474, -1087, 347, -6, 129, -71, -413, -3265, -5898, -7102, -9680, -10071, -11579, -10641, -9241, -7009, -5949, -4177, -1925, 1052, 3962, 4745, 6959, 7745, 8915, 9111, 7155, 6236, 4887, 2393, -1425, -2477, -4388, -6257, -8420, -8166, -10052, -12372, -12271, -11808, -12445, -12597, -12089, -12782, -13874, -13855, -14324, -12181, -11672, -10140, -7944, -5248, -2875, -1301, 1409, 2720, 4984, 7264, 9717, 10735, 12816, 12193, 11172, 11104, 10318, 8446, 5952, 3405, 1996, 417, 374, -1181, -1628, -4151, -6218, -8996, -10691, -12621, -13353, -13584, -13424, -12107, -9812, -6991, -3997, 321, 5438, 9861, 13097, 16407, 19393, 19816, 18511, 17998, 16690, 16020, 13653, 9946, 5741, 4156, 619, 562, -277, -2189, -1780, -2434, -4404, -6010, -6471, -9152, -9678, -10692, -11056, -12554, -13366, -13995, -14548, -15592, -17475, -19913, -17807, -17568, -16378, -15445, -15119, -11776, -9087, -8072, -6148, -6225, 7544, 15184, 11904, 9603, 11108, 12369, 12170, 12228, 11570, 11778, 10900, 12081, 12361, 9971, 8998, 9921, 8626, 7352, 8641, 8575, 7314, 6933, 5662, 6446, 7007, 8898, 9023, 8533, 10077, 9785, 8231, 8574, 7243, 6056, 5525, 8329, 7993, 6938, 8349, 9497, 10402, 9317, 10008, 10171, 7797, 5279, 1467, -3286, -5366, -9863, -15007, -19890, -24297, -28616, -30456, -32130, -30512, -31625, -30267, -26836, -22911, -18987, -15649, -11288, -5835, -3039, -323, 1821, 291, -1617, -42, 461, -731, -543, -162, -680, -167, 2891, 4741, 5149, 8435, 10422, 11857, 12440, 12065, 8228, 6490, 2853, -1271, -5663, -7576, -11829, -11010, -10852, -7069, -6927, -3142, -1554};