/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0029 256 samples */
 
const int16_t AKWF_snippet_0029_256_DATA [256] = 
{473, 1659, 3361, 5021, 6220, 7302, 9113, 10959, 13141, 15938, 17130, 18647, 20045, 20927, 22025, 23318, 24416, 25073, 25949, 27386, 28124, 28532, 28798, 28967, 29340, 29422, 25722, 22906, 21331, 20027, 18880, 18308, 17624, 20054, 23339, 24470, 25569, 26990, 27968, 28393, 28241, 28308, 28125, 27560, 26830, 25805, 25117, 24461, 23630, 22757, 22433, 22505, 22669, 22397, 22136, 22278, 22116, 21907, 21301, 21048, 20525, 18885, 16735, 14721, 12617, 10189, 7855, 6043, 4454, 3628, 3190, 3191, 3398, 3647, 4160, 4836, 5529, 5863, 6316, 6281, 5724, 5195, 4933, 4808, 4338, 3783, 3140, 2156, 1674, 1208, 382, -788, -2244, -3084, -4521, -7483, -11579, -14381, -17153, -19591, -21371, -22489, -28345, -10761, 20201, 15173, 14394, 12231, 9862, 8114, 6834, 5730, 5081, 4047, 3229, 3058, 2867, 3105, 3425, 3326, 3146, 2957, 2412, 1864, 1289, 842, 298, -232, -779, -1322, -2387, -3566, -4893, -6469, -7997, -9096, -10509, -12276, -15373, -19864, -21317, -22621, -24320, -25664, -26135, -26619, -27243, -27594, -28039, -27970, -28270, -28844, -28429, -27634, -26960, -26125, -25676, -24504, -23102, -22401, -21618, -21057, -20444, -20389, -19856, -19234, -18912, -18753, -18096, -17629, -17138, -15961, -14464, -12672, -10832, -11031, -13136, -12267, -10160, -8535, -6086, -844, 4063, 11036, 15906, 18679, 20934, 23006, 24698, 25299, 25336, 25179, 24989, 25146, 25447, 24664, 23534, 22538, 21452, 20041, 18747, 17043, 14920, 12230, 9531, 6287, 2131, -4696, -8210, -10700, -13263, -16708, -19692, -22509, -25059, -27845, -29737, -30731, -31773, -32604, -32739, -32131, -31686, -31006, -30406, -29615, -29242, -28291, -28408, -28325, -27443, -26437, -25046, -23889, -22341, -20714, -18883, -17413, -15771, -14414, -13727, -13408, -13952, -14058, -14181, -14100, -14683, -14916, -13932, -12631, -10796, -8798, -6723, -4997, -3237, -1248};