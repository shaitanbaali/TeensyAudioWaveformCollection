/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0047 256 samples */
 
const int16_t AKWF_snippet_0047_256_DATA [256] = 
{1603, 11058, 10020, 23392, 30076, 27585, 23954, 14801, 13989, -4017, -23597, -22360, -22577, -19196, -12134, -4715, -3439, -1475, -4796, -12012, -9202, -392, 3841, 3906, 5211, 11073, 14729, 11835, 11365, 8608, 1518, -10413, -11179, -12601, -10434, -4380, -4223, 5435, 9631, 12887, 9783, -2564, -4140, 1016, 1179, 3440, 1604, 6789, 58, -3792, -4487, -5645, -10682, -18942, -14932, -7128, 534, 5710, 12945, 22398, 18211, 13194, 9848, 8365, 2365, -9612, -10759, -7304, -8687, -7414, -5294, 394, 3537, 3934, 3253, 2426, 3506, -181, -4404, -1970, 2607, 2271, -812, -1617, -1884, -1217, -10354, -14485, -9765, -8184, -13711, -11340, 427, 9308, 14833, 27782, 12980, 2517, -6357, -1193, -3094, -869, 13733, 14353, 11275, 4294, 1418, -2891, -16890, -19461, -15051, -10528, -12121, -9940, 9836, 21257, 15910, 25111, 24723, 10132, -5790, -20391, -20528, -18404, -8025, -2970, 7283, 11157, 11446, -549, -13279, -9979, -16989, -14323, -9162, 136, 10863, 14524, 15684, 15251, 10946, 9630, 12446, 2878, 652, 4289, 3487, 6410, 2786, -3339, -3711, -16142, -28402, -23547, -23097, -19635, -14999, -7201, 6558, 6323, 5526, 4821, 7781, 13764, 11855, 13579, 15965, 17784, 14859, 18068, 13976, 7373, -1200, -6069, -9710, -11966, -14433, -12574, -8869, -10021, -9619, -8817, -5986, -3507, -1743, -9623, -7577, -3804, 2800, 7023, 5346, 3308, 3249, 4224, 9928, 9334, 9893, 11642, 6049, 3769, 1956, 6287, 960, -187, 5473, 989, -10699, -11130, -9266, -12077, -20136, -23428, -16733, -11127, -5015, -245, 5486, 9617, 2874, 4472, 12588, 13117, 18280, 18793, 28126, 22853, 18933, 11555, 1421, -6324, -12247, -19127, -26257, -23761, -17421, -14139, -12550, -3819, 13663, 16167, 12552, 2748, 365, -1456, -10709, -13009, -7453, 2173, 851, 2913, -1296, -6167, -11641, -9051, -8102, -2882};