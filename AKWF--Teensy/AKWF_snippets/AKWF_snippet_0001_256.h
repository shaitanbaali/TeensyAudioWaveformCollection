/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0001 256 samples */
 
const int16_t AKWF_snippet_0001_256_DATA [256] = 
{1336, 3943, 5536, 6352, 7502, 8617, 9884, 12467, 15787, 18584, 21526, 25045, 27452, 27816, 27287, 26508, 25545, 25126, 25080, 24199, 22721, 21698, 20805, 19750, 19573, 20100, 19616, 18471, 18886, 20962, 22658, 22916, 22341, 22033, 22856, 24714, 26712, 27782, 29932, 31500, 6709, -4557, -1763, -2450, -2570, -3691, -4936, -5232, -5328, -6172, -6910, -6742, -6192, -5793, -5753, -6300, -6742, -5756, -3720, -2832, -3852, -5131, -5475, -5821, -7167, -8801, -9543, -9438, -9433, -10152, -11230, -11859, -11949, -12127, -12611, -13235, -13883, -14132, -13802, -13692, -14311, -14959, -15389, -16013, -16464, -16625, -17097, -17248, -16190, -15223, -15575, -16134, -16138, -16323, -16434, -16027, -16196, -17192, -17601, -17218, -17263, -17916, -18211, -17889, -17727, -18212, -18464, -17743, -17005, -16811, -16051, -14637, -13454, -11653, -8532, -6115, -5764, -6313, -7160, -8022, -7910, -7635, -8658, -9620, -9310, -9760, -11676, -12605, -11890, -10772, -9667, -9337, -10303, -10784, -9677, -8957, -9506, -9654, -9328, -9797, -10356, -9531, -7503, -5601, -4790, -4647, -3761, -1813, 39, 1454, 3012, 4392, 5001, 4894, 4223, 3222, 2232, 913, -1106, -2996, -3986, -4621, -5243, -5187, -4168, -2848, -1744, -528, 1171, 2926, 4151, 4993, 5521, 5421, 5249, 6017, 7409, 8357, 8594, 8296, 7791, 7948, 8962, 9639, 9387, 8780, 8054, 7363, 7301, 7610, 7095, 5292, 2855, 695, -317, -319, -388, -943, -1540, -1778, -1133, 659, 2807, 4735, 7012, 9323, 10406, 10516, 10659, 10592, 10067, 9430, 8005, 5112, 2208, 767, 78, -808, -1428, -1408, -1273, -1324, -1198, -738, -539, -905, -982, -209, 299, -198, -441, 453, 1499, 1966, 2578, 3833, 5192, 5995, 6288, 6690, 7398, 7678, 7287, 6959, 6700, 5566, 3768, 2597, 2330, 1865, 493, -1045, -1456, -930, -719, -364};