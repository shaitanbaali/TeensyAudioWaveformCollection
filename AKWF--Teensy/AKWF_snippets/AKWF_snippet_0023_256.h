/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0023 256 samples */
 
const int16_t AKWF_snippet_0023_256_DATA [256] = 
{1337, 1521, 965, 2906, 4751, 2337, 186, 3229, 4180, 3351, 7394, 9831, 6328, 4764, 7973, 11738, 12432, 13937, 18389, 20307, 20829, 23142, 25402, 26427, 26861, 25494, 26169, 26408, 23706, 21196, 19121, 18069, 16947, 16790, 18126, 18948, 17867, 19414, 21480, 21412, 21657, 22182, 22397, 19239, 18171, 20107, 18410, 14815, 14899, 17645, 17270, 16181, 17369, 18684, 18618, 18699, 19827, 19294, 18973, 21513, 23879, 24456, 24430, 24261, 24217, 23846, 23210, 23268, 23296, 23107, 23069, 22966, 23073, 22505, 21883, 21656, 21457, 21174, 20896, 20978, 20471, 20364, 20754, 20769, 20199, 19900, 20124, 19975, 19380, 18718, 18400, 18392, 17962, 17241, 17659, 17870, 17191, 16916, 16836, 17243, 17607, 17329, 16491, 16459, 17498, 15138, 13751, 14438, 12685, 10265, 7584, 7522, 9334, 11921, 14434, 13848, 12864, 13285, 13301, 11961, 11356, 12884, 13392, 12965, 12904, 11504, 6791, 3797, 6786, 9686, 9447, 5087, 2878, 6801, 8990, 8896, 9477, 9294, 6150, 2234, 1970, -396, -7726, -10602, -9028, -9267, -10435, -9512, -5929, -5794, -9117, -12924, -16471, -13272, -8202, -7877, -12876, -16118, -15789, -18911, -20942, -21499, -21242, -20120, -23247, -25921, -23964, -24725, -28257, -28237, -24428, -23493, -25275, -25943, -25929, -23937, -21076, -13595, -7717, -11719, -19585, -24853, -23037, -20182, -22794, -20438, -15227, -16852, -18661, -19642, -19474, -17284, -16609, -14826, -12880, -12111, -9918, -13422, -21207, -22735, -21289, -24114, -24124, -22277, -27041, -29822, -29106, -29058, -29199, -27518, -25684, -26742, -28244, -29329, -29255, -27412, -28133, -31860, -32434, -28164, -25206, -27328, -30122, -31197, -29848, -28158, -27062, -24762, -24431, -25746, -25118, -25744, -26374, -25447, -24444, -24228, -22608, -22822, -24549, -22384, -22998, -23076, -22419, -21784, -20317, -18230, -18841, -12452, 9809, 5899, 4473, 3401, -1197, -5437, -5304, -1819};