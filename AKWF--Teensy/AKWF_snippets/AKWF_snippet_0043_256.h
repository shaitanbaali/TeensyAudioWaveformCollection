/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0043 256 samples */
 
const int16_t AKWF_snippet_0043_256_DATA [256] = 
{658, 1159, 1464, 7347, 19958, 12823, 2005, 23945, 30763, 18843, 15157, 17800, 3182, -7675, 1120, 5722, -10974, -923, -3056, -12201, -2043, -1820, -6732, -3440, -4970, -701, -493, -6241, -823, 11071, 13349, 11328, 8272, 10275, 5203, 2027, 11970, 19130, 12187, 1665, -6579, -10105, -13674, -18662, -18370, -15416, -11827, -10558, -12794, -13762, -7247, 890, 7415, 11106, 15410, 18109, 15399, 9271, 2025, -2098, -3792, -5110, -6975, -6904, -8840, -9051, -7524, -7907, -9145, -10786, -11175, -10069, -7926, -5025, 938, 4298, 6724, 9628, 8914, 5573, 1056, -1782, -4969, -7804, -6568, -3985, -2014, -2297, -3023, -1404, 770, 3478, 3474, 2444, 3237, 2906, 2389, 4718, 6418, 4436, 2996, 3248, 5668, 9287, 11765, 11481, 9588, 6797, 3732, 1519, -1555, -5437, -7520, -10320, -11884, -11567, -11085, -11382, -11230, -8150, -3283, 114, 4609, 8312, 10517, 12559, 11849, 10205, 8262, 6561, 6031, 5917, 5454, 4634, 1958, -1585, -5476, -7889, -8852, -10094, -8754, -6687, -5488, -1287, 3248, 6048, 8600, 8889, 7785, 4411, 714, -59, -1708, -1958, -1543, -764, -429, -758, 32, 1811, 1677, 999, 1211, 1185, 2461, 3473, 3432, 3858, 3547, 2758, 2370, 2778, 3044, 2867, 2871, 2559, 2760, 995, -742, -3249, -5895, -7408, -9551, -11729, -12497, -14983, -15782, -10792, -6400, -5485, -6874, 1242, 3474, 4071, 2919, 5661, 5991, 7126, 5502, 4456, 4264, 4756, 4913, 2480, 4212, 536, -3135, -5078, -8811, -9857, -3235, 2182, -3358, 1545, 8882, 4020, 2812, 4954, -4276, -8060, -5795, 5380, 14811, 6583, -10241, 3075, 3609, -4990, -8243, -11455, -3723, -11480, -5179, 1927, -7311, -2631, 7941, 13319, 19624, 15276, 9518, 6126, 8725, 2935, -6342, -4707, -6725, -13838, -20872, -25593, -20938, -19482, -16635, -3795, -1443, -1578};