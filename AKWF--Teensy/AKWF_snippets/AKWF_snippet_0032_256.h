/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0032 256 samples */
 
const int16_t AKWF_snippet_0032_256_DATA [256] = 
{2112, 4342, 3172, 4281, 4837, 3464, 5510, 8757, 8371, 10693, 16682, 16972, 13198, 10613, 7269, 6159, 9338, 11606, 12823, 15308, 16219, 13532, 9929, 7742, 5604, 4508, 8959, 15666, 16928, 15139, 16380, 17623, 14552, 12924, 17364, 21826, 23613, 25593, 25938, 25261, 27289, 28202, 23975, 19295, 20125, 25976, 31218, 32807, 31161, 27464, 24729, 23688, 22473, 22503, 24270, 25385, 24388, 21599, 21202, 25572, 29396, 29496, 27606, 25704, 26574, 29278, 29521, 27390, 24522, 21567, 21217, 24017, 25263, 21677, 17845, 18355, 18544, 15345, 15085, 18820, 21485, 3478, -8976, -6828, -7383, -11600, -5685, 2184, -3394, -7005, 200, 4814, 3084, -247, -3888, -4489, -2263, -1527, 261, 4545, 5353, 2961, 2543, 2612, 714, -1728, -2844, -1533, 1351, 4146, 5378, 4673, 5621, 8306, 6316, 644, -2106, -1690, -1, 1919, 3073, 4628, 5289, 2519, -1035, -3014, -4296, -4402, -2972, -882, 733, -502, -3505, -2200, 2702, 2631, -2596, -6201, -6239, -3198, -127, -2889, -6872, -4172, -1033, -3415, -4866, -3318, -4943, -9612, -11395, -11356, -14133, -15032, -9399, -5308, -8936, -14037, -16041, -17006, -18633, -20827, -22029, -20257, -16043, -11469, -10019, -13767, -18312, -21165, -23456, -20054, -12837, -13950, -19896, -21582, -22512, -20888, -16442, -19732, -26531, -26282, -23566, -22064, -22009, -23684, -21419, -15993, -15179, -18589, -20992, -19922, -19520, -23147, -24964, -22562, -20606, -20769, -21685, -17295, -9825, -13030, -22799, -26753, -25678, -15228, -2170, -6466, -15241, -12407, -16107, -24310, -17793, -9161, -10646, -10108, -8018, -12773, -13289, -4134, -2403, -12662, -17847, -10470, -2409, -6162, -16860, -18609, -12184, -9632, -8747, -4413, -2699, -6731, -11443, -11145, -7714, -9057, -12179, -5948, 3523, 1458, -4332, -735, 1, -10830, -15894, -9393, -2802, 2510, 5085, 1367, -1222, -1708, -4639, -3652};