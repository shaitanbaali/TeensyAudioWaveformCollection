/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0035 256 samples */
 
const int16_t AKWF_snippet_0035_256_DATA [256] = 
{550, 4436, 7357, 10492, 15490, 21672, 27561, 31045, 29700, 26220, 15894, 9860, 2487, -4118, -11057, -17875, -23422, -26949, -24833, -18168, -8160, -3685, 3222, 9458, 14473, 19152, 20899, 21599, 17589, 8410, 716, -5435, -11339, -15448, -18489, -20250, -20382, -18916, -15526, -12331, -9376, -7814, -6941, -6865, -6308, -2565, -31, 3703, 6772, 6989, 9620, 12042, 15419, 20171, 24717, 27714, 26742, 21331, 13403, 8912, 1496, -4612, -11157, -17450, -22822, -24089, -21256, -16601, -11080, -3797, 2982, 8953, 14306, 19455, 21795, 20831, 14982, 9966, 3051, -3729, -9280, -13663, -17299, -18786, -19031, -17864, -15201, -12997, -9864, -7501, -5931, -4940, -4867, -2571, 1711, 4374, 6173, 8160, 10066, 13224, 17151, 21913, 26557, 27558, 24831, 20055, 13954, 6613, -313, -6909, -13660, -19800, -23857, -25040, -24708, -21415, -15276, -6503, 1296, 8321, 14205, 18923, 22005, 21921, 20267, 15435, 8110, 362, -6360, -11889, -15831, -18627, -19051, -17227, -14580, -9448, -3099, 4053, 9292, 11440, 14082, 14921, 14830, 13903, 12372, 10798, 9338, 9275, 10962, 12233, 14062, 13789, 12638, 8887, 3686, -643, -5695, -9821, -14939, -18771, -23085, -24273, -24481, -21367, -15407, -7639, 404, 7858, 14026, 18522, 22016, 23056, 21365, 17209, 9886, 873, -5009, -10973, -15187, -18578, -20101, -19342, -16674, -12325, -6817, -1023, 4616, 8807, 12228, 13969, 14236, 13547, 12346, 10627, 8864, 8468, 8415, 9625, 10377, 11630, 10483, 7278, 3135, -768, -4458, -8611, -12206, -16250, -20188, -22600, -22545, -19259, -11838, -6267, 887, 7281, 13565, 18182, 21897, 23905, 23359, 20257, 14950, 7698, 339, -6237, -12365, -16399, -19290, -20238, -18300, -15606, -11979, -7181, -2179, 2681, 7169, 9486, 11255, 11712, 11305, 11182, 7442, -3499, -9981, -14849, -16431, -17141, -18482, -22084, -24676, -28268, -30518, -29490, -22658, -9315};