/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0036 256 samples */
 
const int16_t AKWF_snippet_0036_256_DATA [256] = 
{1047, 4100, 7394, 10810, 14315, 17855, 21293, 24481, 27319, 29667, 31401, 32435, 32768, 32473, 31659, 30409, 28797, 26886, 24728, 22425, 20065, 17640, 15157, 12602, 9935, 7156, 4251, 1203, -1915, -5046, -8100, -10984, -13693, -16135, -18263, -20043, -21405, -22378, -22967, -23201, -23092, -22634, -21873, -20806, -19460, -17895, -16170, -14357, -12520, -10608, -8660, -6628, -4480, -2259, 7, 2308, 4594, 6810, 8868, 10750, 12390, 13730, 14667, 15119, 15090, 14570, 13633, 12332, 10737, 8923, 6959, 4906, 2787, 616, -1554, -3755, -5974, -8191, -10379, -12527, -14595, -16568, -18366, -19962, -21312, -22367, -23151, -23645, -23882, -23911, -23749, -23381, -22816, -22061, -21123, -20024, -18754, -17312, -15643, -13696, -11489, -9115, -6704, -4293, -1894, 521, 2933, 5368, 7717, 9928, 11959, 13820, 15481, 16982, 18291, 19378, 20131, 20540, 20589, 20261, 19547, 18498, 17145, 15551, 13736, 11757, 9693, 7633, 5620, 3649, 1706, -185, -2005, -3735, -5341, -6829, -8216, -9501, -10674, -11692, -12523, -13150, -13573, -13808, -13866, -13760, -13495, -13041, -12353, -11379, -10154, -8688, -7062, -5302, -3454, -1548, 384, 2360, 4298, 6191, 7982, 9659, 11205, 12599, 13856, 14994, 16007, 16897, 17643, 18212, 18586, 18758, 18681, 18399, 17903, 17178, 16253, 15169, 13895, 12496, 10981, 9339, 7651, 5933, 4207, 2499, 834, -745, -2232, -3622, -4901, -6053, -7074, -7961, -8780, -9901, -11286, -12590, -13579, -14195, -14538, -14635, -14404, -13720, -12522, -10793, -8568, -5978, -3141, -226, 2694, 5467, 8050, 10369, 12337, 13900, 15085, 15899, 16403, 16617, 16599, 16341, 15848, 15128, 14184, 13020, 11678, 10121, 8409, 6499, 4333, 1870, -936, -4042, -7297, -10607, -13827, -16841, -19596, -21953, -23801, -25093, -25748, -25760, -25127, -23917, -22250, -20274, -18114, -15831, -13490, -11102, -8752, -6449, -4085, -1463};