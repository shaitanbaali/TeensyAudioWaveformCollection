/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0040 256 samples */
 
const int16_t AKWF_snippet_0040_256_DATA [256] = 
{5379, 14258, 11682, 5541, 3338, 4688, 13670, 8973, 4997, 14457, 31034, 23336, 8259, 15808, 8892, -6557, -8308, -18079, -16357, -15695, -25301, -22413, -21953, -22188, -24281, -18417, -15678, -9621, -8676, -14216, -11115, -12498, -13467, -9207, -12192, -9872, -2666, 2018, 8697, 11055, 8536, 11002, 7187, 4842, 7970, 5577, 1917, 2342, 1582, 7587, 9425, -8505, -6277, -9383, -9619, 1959, 6456, -21, -1393, 4463, 6400, 7442, 1705, 299, 2980, 9015, 13242, 19609, 16883, 5312, 2246, 2237, 2718, 8321, 1028, 1591, -1234, -5675, -3151, 4980, 811, 4755, 4123, -1011, 1399, -5272, -1028, 3665, 2408, -747, 1867, 8160, 4843, 4204, 4307, 13581, 13009, 207, -1135, -3194, -3094, -3813, -9425, -8192, -3398, -1840, -6370, -9132, -8650, -11103, 2285, -543, -6003, -6022, -6310, -5850, -10401, -14699, -13339, -9046, -14646, -12665, -5775, -9457, -8501, -9061, -12522, -2499, 39, -9653, -6110, 594, -392, -7291, 4701, 14201, 10826, 7542, 4434, -538, 3912, 16866, 13591, 15471, 14120, 11976, 18576, 3662, 744, 12508, 13082, 3229, 1456, 4344, 6817, -3511, -2123, 3203, 2515, 6678, 11220, 9703, 7063, 3803, 6936, 8580, 5942, 5961, 9440, 5247, 2529, 9543, 11721, 3981, -4627, -9579, -6693, -6178, -11850, -15180, -18366, -18705, -16802, -12484, -17892, -16053, -16826, -24194, -24452, -17546, -5166, 488, -3459, -9098, -5907, -61, 238, -6370, 3690, 11015, 3086, -6551, 8494, 13793, 10975, 1372, 7815, 8494, 9987, 11611, 5352, 5276, 11741, 18927, 9255, 10674, 17038, 6831, 3110, 8977, 4642, 1244, 8707, 10143, -10786, -14780, -15857, -10007, -6057, -5604, -1193, 2462, -715, -19271, -7044, -13809, -28939, -17624, -10220, -8596, -17908, -18830, 3054, 10970, -1643, 1455, 13947, 13014, 24671, 19385, 14979, 7646, 11505, 9722, 4991, 1624};