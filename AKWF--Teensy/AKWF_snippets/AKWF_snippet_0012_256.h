/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0012 256 samples */
 
const int16_t AKWF_snippet_0012_256_DATA [256] = 
{805, 2713, 4565, 6512, 9082, 9997, 10994, 11823, 14585, 16468, 17731, 18557, 18888, 19159, 19135, 19256, 19662, 20206, 20311, 20314, 20213, 19586, 19514, 19455, 19455, 19102, 18928, 19098, 18760, 18340, 18005, 18638, 18142, 17275, 17228, 17089, 17056, 17134, 16723, 17102, 16333, 16000, 16097, 16186, 15590, 15248, 15106, 15078, 14874, 14834, 14831, 16650, 15616, 11828, 10699, 13224, 12617, 12514, 13021, 13511, 12543, 10372, 5472, 16313, 6009, 3444, 19146, 14147, -5280, 9407, 7234, -628, 5292, 1502, 669, 550, -5813, -4088, -3073, -1494, -841, -10747, -8842, -2255, -13956, -14859, 7, -13120, -14173, -9925, -18880, -13105, -21184, -20696, -22656, -15211, -20597, -24539, -27117, -23455, -22933, -29624, -22648, -22762, -29605, -31081, -20507, -28547, -17164, -6414, -6306, -3837, -2464, -793, 133, 583, 1234, 1807, 1920, 1941, 2099, 2829, 3260, 3162, 3415, 4172, 4876, 5453, 5978, 6939, 8053, 8305, 8025, 8934, 9644, 9674, 9775, 10299, 10960, 11085, 10709, 10248, 10145, 9893, 10105, 9815, 9694, 9235, 8749, 8646, 8176, 7636, 7078, 6110, 5256, 4698, 3530, 2848, 1882, 1084, -109, -946, -1387, -2273, -3528, -4409, -4770, -5186, -5845, -6433, -6804, -8276, -9574, -10818, -11776, -12471, -13401, -13951, -13981, -13897, -14683, -14745, -14761, -15275, -15637, -15658, -15004, -13298, -11416, -8667, -5749, -3445, -1262, -21, 1638, 3992, 6166, 9532, 12914, 15285, 17596, 19564, 21047, 22098, 22554, 22098, 20623, 18365, 14577, 10324, 4781, -1449, -6080, -9530, -12778, -15824, -18263, -20195, -20977, -21669, -22390, -23429, -23834, -24028, -24440, -24361, -24323, -24281, -24116, -23541, -23371, -23152, -22196, -21779, -21002, -20016, -19420, -18608, -17460, -16496, -15377, -15071, -14840, -13975, -13462, -12501, -11352, -10827, -9730, -8702, -8402, -7455, -5239, -3261, -1690, -762};