/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0018 256 samples */
 
const int16_t AKWF_snippet_0018_256_DATA [256] = 
{1301, 6907, 14602, 22053, 28055, 31953, 32489, 29005, 22819, 15824, 9337, 4585, 2699, 3677, 6474, 10323, 14166, 16571, 16713, 14782, 10822, 5273, -286, -4388, -6572, -6707, -4479, -594, 3440, 6555, 8373, 8546, 6814, 3354, -1374, -6576, -11076, -14072, -15315, -14912, -13000, -10001, -6720, -4119, -2917, -3295, -5148, -8142, -11542, -14326, -16092, -16786, -16118, -13959, -11283, -9130, -7588, -6751, -7341, -9714, -13038, -16396, -19235, -21061, -21196, -19452, -16365, -12903, -9864, -7517, -6119, -6134, -7672, -9781, -14355, -14653, -2935, -43, 1381, 7008, 13571, 19191, 22164, 22819, 21582, 18310, 13698, 9492, 6745, 5522, 5885, 7610, 9779, 11385, 12105, 12149, 11917, 11624, 11177, 10395, 9223, 7505, 5286, 3188, 1908, 1662, 2564, 4602, 7158, 9382, 10799, 10902, 9005, 5248, 520, -4342, -8552, -10807, -10353, -7570, -3296, 1679, 6162, 8849, 8818, 5793, 289, -6322, -12498, -17111, -19061, -17782, -13844, -8659, -3287, 1052, 2980, 1612, -2861, -9376, -16064, -20872, -22778, -21310, -16187, -8118, -12, 5213, 6035, 2171, -5416, -14069, -20632, -23228, -20996, -14276, -5092, 3519, 9642, 12315, 11132, 6795, 1107, -4437, -8712, -10541, -9353, -5642, 73, 7289, 14378, 19272, 20694, 18209, 12131, 4180, -3130, -7880, -8791, -5271, 1823, 10456, 18625, 24754, 27117, 25042, 19498, 12207, 4641, -1814, -5885, -6933, -5057, -1251, 3112, 6779, 8948, 8857, 6325, 2088, -2688, -6964, -9742, -10485, -9703, -8181, -6376, -4718, -3863, -3924, -4843, -6780, -9728, -13075, -16421, -19701, -22240, -23113, -21902, -18792, -14227, -9211, -4712, -1202, 874, 758, -1613, -5522, -10060, -14393, -17442, -18210, -15952, -10482, -2863, 4887, 10996, 14502, 14430, 10900, 5599, 574, -3014, -3905, -991, 5165, 12606, 19681, 25247, 27650, 25950, 20748, 13767, 6780, 1458, -545};