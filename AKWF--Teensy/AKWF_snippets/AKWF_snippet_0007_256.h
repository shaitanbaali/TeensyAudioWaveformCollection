/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0007 256 samples */
 
const int16_t AKWF_snippet_0007_256_DATA [256] = 
{1530, 6755, 10635, 13130, 16024, 19018, 20122, 19288, 18392, 18808, 19936, 21099, 21970, 22837, 23774, 24045, 23763, 24344, 26382, 27665, 26005, 22041, 17945, 14563, 11178, 8078, 5254, 2786, 706, -1268, -2247, -1034, 2707, 7138, 9982, 11809, 14259, 16049, 15764, 13869, 13097, 14474, 15933, 15745, 14551, 14116, 14925, 15778, 16048, 17273, 19400, 19765, 17067, 12855, 9171, 6204, 3044, -813, -4563, -7527, -9868, -11327, -10977, -8021, -3648, -699, 857, 3272, 6201, 7145, 5385, 2820, 1453, 1281, 298, -2792, -4644, -5730, -6579, -8070, -9119, -8378, -7186, -8245, -12134, -16645, -20229, -23273, -26152, -28162, -32858, -23493, 4845, 358, -704, -1489, -1642, 151, 4191, 8561, 11186, 12444, 13471, 14120, 13044, 10825, 9914, 10588, 11774, 12622, 12629, 12792, 13296, 13950, 14315, 15231, 16808, 16901, 14232, 9822, 5456, 1958, -1823, -5901, -9162, -11239, -12394, -12641, -12126, -9793, -6011, -2487, -584, 62, 459, 294, -3306, -8765, -11466, -11786, -11503, -11133, -11396, -12093, -13176, -13839, -13927, -12620, -10787, -10942, -14160, -18306, -21450, -23707, -25703, -27400, -28511, -29260, -29883, -29934, -28278, -24464, -19022, -14343, -11278, -8240, -5410, -4062, -4660, -5098, -3423, -460, 1734, 2828, 4310, 7174, 10116, 12557, 14486, 17238, 19542, 18734, 15096, 11327, 8184, 5078, 1510, -2440, -5783, -7744, -9142, -9553, -8685, -6406, -3670, -2842, -3847, -3170, -2605, -4363, -7787, -10171, -10495, -9590, -8727, -8287, -7787, -7316, -7551, -7721, -6561, -4460, -3573, -5435, -9244, -12777, -15420, -17872, -20100, -21506, -22337, -23285, -24119, -23626, -20601, -15648, -10604, -7083, -4535, -1680, 6, -565, -2022, -1664, 591, 2618, 3235, 3656, 4872, 6234, 7234, 8598, 10991, 13293, 13574, 10791, 6742, 3771, 1583, -605, -2278, -3709, -4752, -5256, -4849, -2556};