/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0039 256 samples */
 
const int16_t AKWF_snippet_0039_256_DATA [256] = 
{7215, 7144, 8876, 7995, 15024, 7746, 9605, 15473, 16725, 23864, 23266, 25963, 29416, 26020, 29815, 28977, 30062, 30407, 30335, 30339, 30334, 30329, 30323, 30320, 30309, 29700, 30225, 30310, 30283, 30280, 30272, 30265, 30259, 30251, 30244, 30237, 30229, 30222, 30214, 30207, 30199, 30192, 30185, 30176, 30169, 30161, 30153, 30145, 30137, 30129, 30121, 30114, 30105, 30097, 30089, 30081, 30074, 30066, 30057, 30050, 30042, 30034, 30025, 30018, 30010, 30002, 29994, 29986, 29978, 29969, 29962, 29953, 29946, 29937, 29930, 29922, 29913, 29906, 29897, 29890, 29881, 29873, 29865, 29858, 29849, 29842, 29833, 29826, 29817, 29810, 29801, 29794, 29785, 29777, 29770, 29762, 29754, 29746, 29738, 29730, 29722, 29714, 29706, 29698, 29690, 29682, 29674, 29666, 29658, 29650, 29642, 29633, 29626, 29618, 29610, 29602, 29582, 29683, 29111, 28697, 28425, 26087, 28866, 24125, 22826, 21142, 15614, 7785, 1440, 8749, 14032, 6998, 7923, 6991, 3471, -2865, -16332, -19983, -9120, -12429, -21507, -22299, -22157, -30746, -33142, -32659, -32759, -32757, -32753, -32749, -32745, -32739, -32733, -32728, -32722, -32716, -32710, -32703, -32696, -32689, -32682, -32675, -32668, -32659, -32652, -32645, -32636, -32629, -32620, -32613, -32604, -32596, -32588, -32579, -32571, -32563, -32555, -32546, -32537, -32529, -32521, -32512, -32503, -32494, -32487, -32478, -32469, -32461, -32451, -32443, -32436, -32427, -32418, -32409, -32400, -32391, -32382, -32375, -32367, -32357, -32349, -32340, -32331, -32322, -32315, -32306, -32297, -32288, -32279, -32270, -32261, -32253, -32245, -32237, -32228, -32219, -32210, -32201, -32192, -32185, -32176, -32167, -32159, -32150, -32141, -32132, -32125, -32116, -32107, -32098, -32089, -32080, -32072, -32065, -32055, -32047, -32038, -32029, -32020, -32013, -32004, -31995, -31986, -31977, -31960, -31866, -32370, -25900, -18514, -23425, -15218, -7012, -12577, -20576, -5845, 815};