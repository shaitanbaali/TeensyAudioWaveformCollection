/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0031 256 samples */
 
const int16_t AKWF_snippet_0031_256_DATA [256] = 
{1469, 3199, 5178, 5957, 5514, 5680, 8131, 13139, 16238, 14723, 11003, 7475, 7731, 9609, 7213, 6191, 10495, 13875, 14621, 13374, 11828, 13080, 15676, 18538, 21028, 21322, 21033, 21012, 20155, 19056, 19591, 21509, 21954, 22003, 23228, 22381, 20091, 19601, 19399, 17720, 15999, 15493, 14911, 14835, 16102, 15161, 12861, 13151, 13481, 12661, 13572, 15345, 15991, 16724, 17507, 16599, 15301, 13990, 11015, 7843, 9221, -2574, -20290, -15522, -14004, -13424, -11636, -9184, -7819, -8933, -12217, -12764, -9206, -5098, -2274, -664, 2125, 6131, 7951, 6285, 2106, 460, 3871, 6433, 7001, 9089, 11440, 12441, 11420, 9603, 9599, 10104, 10275, 11515, 13958, 16458, 16980, 15966, 15012, 14022, 14582, 16431, 16659, 15960, 16199, 17263, 18106, 17791, 17230, 18088, 20181, 21511, 21900, 23364, 24865, 24605, 23570, 22492, 22156, 22604, 22240, 21466, 21710, 23004, 23489, 21767, 20036, 19651, 19825, 20378, 19672, 17618, 15867, 14753, 15913, 18612, 19530, 18676, 16693, 14964, 15129, 15231, 15147, 16159, 16563, 15616, 14745, 15234, 15123, 11532, 7418, 6782, 8268, 8763, 7442, 5905, 2861, -1958, -2307, 1288, 1806, 659, 527, -1026, -4115, -7171, -8405, -8794, -11902, -13002, -7997, -5133, -7254, -8313, -10183, -16322, -22868, -25979, -26155, -26314, -27864, -29049, -27868, -25882, -26975, -29433, -29066, -28220, -29585, -31463, -32633, -32477, -30445, -27551, -26502, -27773, -27484, -24633, -23090, -23980, -24654, -23586, -22999, -23997, -24232, -23353, -22841, -23215, -23865, -23347, -21974, -21026, -21208, -22049, -22101, -22490, -23154, -21535, -18982, -17701, -18013, -19033, -18783, -18820, -19641, -18894, -18073, -18139, -17670, -17207, -18753, -20720, -17581, -13793, -18379, -25146, -26107, -23040, -19528, -20101, -24375, -27061, -27010, -25650, -25007, -24902, -22947, -20379, -20387, -22940, -22781, -17738, -15122, -15212, -9993, -2157};