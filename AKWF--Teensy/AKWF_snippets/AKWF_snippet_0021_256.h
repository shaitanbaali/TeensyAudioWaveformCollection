/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0021 256 samples */
 
const int16_t AKWF_snippet_0021_256_DATA [256] = 
{3671, 17319, 21910, 25808, 26862, 21998, 18584, 12538, 10012, 7161, 338, -1987, -1364, -6902, -5322, -3007, -4400, -1200, -3226, -5174, -5965, -7290, -8694, -9178, -11418, -14261, -11660, -17394, -20660, -16154, -12120, -13622, -13223, -7211, -6488, -5236, -122, 5487, 14322, 17895, 16807, 19661, 16285, 15834, 15179, 16907, 18380, 15420, 12663, 13342, 9640, 10245, 11456, 8764, 8243, 7087, 5150, 6179, 6532, 4854, 4874, 1450, -3681, -3211, -10155, -21187, -24521, -25341, -26584, -28181, -24477, -19672, -17111, -12718, -9221, -3243, 3581, 4547, 8494, 9824, 11186, 9813, 6461, 5909, 4964, 2227, 5942, 9257, 11157, 14843, 13073, 8621, 7538, 4988, 8149, 11769, 11878, 12560, 11971, 5020, 1727, 295, -7508, -6208, -1823, 1227, -1266, -3233, -4977, -11518, -15220, -13565, -7013, 4405, 9083, 10366, 9537, 4357, 246, -4267, -5646, -6817, -11482, -14112, -13023, -13595, -9368, -4799, -3611, 1733, 3527, 4493, 4013, 3690, 2307, 2118, 1076, 2202, 5298, -45, -2095, -747, 2601, 1593, 842, 2724, -2107, -4771, -3759, 1125, 16435, 20193, 8891, -10424, -23918, -31574, -29607, -28180, -15223, 3007, 20271, 27181, 16315, -746, -8236, -11658, -8644, 799, 5665, 9055, 10908, 1363, -8052, -7362, -3584, -5662, -6059, -2111, -979, -968, 1907, 5588, 15907, 22266, 23887, 22152, 12595, 8141, 709, -2618, 46, 1702, 2641, 7580, -430, -5642, -10149, -21285, -23282, -18463, -12568, -2402, 5123, 6053, 4887, 3950, -2478, -3476, -10972, -20455, -17817, -10144, -5924, -4119, 2046, 9338, 6985, 7284, 6042, 5963, 11103, 9270, 14754, 15060, 11566, 7537, 5415, 3606, 2176, -4470, -5237, -5941, -6959, -2221, -233, -1106, 4116, 3757, 1444, 2660, 158, -5095, -6666, -9855, -6897, -5765, -11967, -10931, -9031, -7896, -11003, -11800, -8184, -11251, -9971, -5680};