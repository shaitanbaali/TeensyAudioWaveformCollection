/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0033 256 samples */
 
const int16_t AKWF_snippet_0033_256_DATA [256] = 
{4150, 6777, 4789, 2077, 2613, 9982, 6645, 4362, 7833, 9250, 8179, 10018, 6267, 10289, 11559, 5513, 5400, 11025, 17105, 10723, 7457, 9403, 9825, 8683, 6509, 4257, 117, -1199, 2947, 1894, -2611, -2367, -1556, -4468, -3300, -862, 308, -2621, -8413, -7276, -6831, -4896, -6292, -6608, -11069, -10813, -7053, -3731, 1025, 35, -3279, -4039, -6959, -10602, -6320, -7661, -7360, -3817, -6038, -9458, -12998, -11525, -5852, -2674, -3811, -3590, -4370, -3050, 832, 3935, -959, 1393, 3451, 1757, -137, -3910, -1049, 4143, 4983, 7161, 5260, 6300, 3361, 3158, 1629, 5100, 8360, 4646, 4906, 11878, 9614, 8736, 7587, 3875, 5968, 4790, 1722, -811, 1010, 2944, 8461, 10991, 8093, 4129, 4047, 5173, 2915, 1756, 4473, 4432, -292, 369, 1065, -72, -1251, -4144, -4107, -2802, -2617, -1364, -1411, -4096, -3454, -4313, -5330, -3811, -1671, -5864, -9363, -5237, -8326, -13388, -4511, 1416, -4273, -4325, -6170, -8599, -5030, -2324, -1447, -2675, -4519, -3601, 93, -5372, -5555, 1271, 147, -2727, 3602, 6337, 1449, -5974, -4577, -2984, -1171, 5411, 4371, 3201, 3502, 903, 4025, 4010, 1870, -2389, -666, 3742, 2336, 5993, 1326, 564, 4923, 4237, 4054, 6315, 5880, 2521, 4741, 1816, 9566, 21544, 12508, 4649, -5377, -8118, -7576, -3843, -783, 4075, -2628, -1853, 7365, 6466, -1272, -15503, 10, -14786, -27902, -27763, -4978, 9987, 10502, 5216, 20824, 10632, -7214, -10688, -3286, 3481, 7418, 2618, 8229, 13870, 24602, 6929, -11493, 1745, 12069, 14058, 1709, -6685, -21645, -4356, 19432, 12779, -1732, -17269, -18952, -10849, -4024, -918, -13455, -8900, -2080, -10192, -16677, -22019, -19968, -430, 7164, 11981, 1943, -4196, -2658, -11196, -9669, -6850, -7768, -1602, 2272, -2861, -3470, -7, 3288, -164};