/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0008 256 samples */
 
const int16_t AKWF_snippet_0008_256_DATA [256] = 
{1225, 5366, 8374, 9451, 9784, 11039, 13699, 17351, 18343, 17007, 16822, 18150, 18911, 19022, 20171, 22587, 23853, 22702, 19933, 16717, 13465, 10187, 6916, 2562, -3533, -8886, -12201, -12778, -9595, -5500, -2222, 827, 2925, 5808, 9125, 9899, 10675, 11636, 12304, 12168, 10188, 8249, 8346, 9720, 10250, 9926, 10490, 11442, 11979, 11103, 8525, 5139, 710, -4705, -9716, -14132, -17828, -20113, -21951, -23448, -23477, -21813, -19116, -16280, -13583, -11166, -9155, -10716, -14555, -16283, -15797, -14348, -12987, -10781, -9206, -9440, -10273, -9446, -6133, 561, 8304, 13547, 14844, 13021, 10478, 7336, 3734, -2202, -8420, -12320, -14522, -14811, -13193, -6646, 3923, 13517, 17149, 15070, 12294, 13575, 19646, 25292, 29251, 30927, 29898, 29875, 16608, -5258, -295, 2654, 7874, 11161, 11424, 12000, 13023, 12579, 9913, 6226, 3485, 1324, -912, -2927, -4044, -3276, -425, 4040, 7872, 10768, 14015, 16835, 16635, 15130, 15771, 18020, 18954, 18070, 16060, 14023, 14060, 15781, 17823, 20635, 25023, 28520, 29417, 28296, 26572, 24244, 20453, 16264, 12157, 6629, 404, -4608, -6923, -6956, -5293, -2675, -754, 870, 3262, 6492, 8605, 8946, 8800, 8727, 7550, 4996, 2325, 481, 651, 2038, 2693, 2534, 4323, 7648, 10145, 9693, 6964, 3748, -683, -6756, -11357, -14695, -17892, -21141, -23889, -25665, -25442, -23809, -21171, -18351, -14727, -9944, -7323, -8314, -10298, -11167, -11024, -11757, -13966, -16010, -16596, -15913, -15253, -13726, -10117, -6255, -4785, -6221, -9149, -11922, -14289, -16843, -19471, -22764, -26474, -29908, -32405, -32448, -29697, -24995, -20379, -17162, -14166, -10791, -8025, -7240, -7578, -7525, -6981, -7786, -10307, -11929, -10794, -8574, -7063, -5739, -3777, -1220, 481, 156, -875, -2559, -5269, -8368, -10606, -12516, -14963, -17579, -19926, -20171, -17020, -11674, -6572, -2542};