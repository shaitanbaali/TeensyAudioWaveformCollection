/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0009 256 samples */
 
const int16_t AKWF_snippet_0009_256_DATA [256] = 
{2722, 3062, 7385, 15653, 28476, 31740, 30240, 26964, 14798, 951, -4330, -3639, -3170, -3069, -1586, 7184, 9789, 9831, 11266, 8492, -611, -11102, -18023, -23078, -18592, -6693, 7985, 14947, 15220, 9584, 478, -9434, -12878, -14531, -12776, -11566, -9628, -8730, -3936, 1197, 2932, 389, -8477, -15551, -16982, -10681, -1562, 9165, 16853, 12707, 4270, -3851, -7774, -10886, -11405, -10771, -13823, -17232, -14125, -2928, 9482, 15215, 18261, 18974, 10710, -810, -7472, -12465, -14103, -17300, -7971, 1548, 9465, 11100, 10185, 9040, 3217, -3229, -8840, -11954, -17895, -14957, -10128, -2118, 1775, 5169, 2840, -68, -5958, -8917, -13606, -13597, -9614, -7433, -4753, -5799, -8852, -9632, -4502, 10270, 16733, 18090, 17952, 6185, -6873, -11291, -13545, -12034, -5008, -2147, -319, -2001, -2483, 709, 8035, 14730, 18719, 20021, 14154, 3826, -4216, -4079, -1207, 6658, 11646, 9789, 6886, 4627, 2832, 8341, 9424, 6454, 150, -6209, -5481, -6903, 5852, 20090, 24638, 22243, 5146, -3471, -6190, -14489, -13426, -7747, -1377, -4864, -651, 6031, 7770, 7681, 10333, 3405, -4219, -6420, -4512, -4416, -4481, -8597, -8285, -6266, -6215, -4522, -5178, -6897, -13599, -17481, -18220, -13463, -5159, 7015, 15343, 15122, 9763, -714, -6778, -14279, -20205, -20421, -14799, -6921, 3857, 9822, 14307, 12895, 7841, 2112, -7093, -14419, -13011, -7675, 2356, 15476, 19262, 20029, 18002, 11802, 3551, -8807, -16754, -21272, -21930, -19128, -7872, -3961, 3145, 6796, 10495, 7475, 603, -11349, -22939, -23444, -22960, -19322, -10772, -1126, 2542, 4391, 4453, 902, -4198, -9930, -14477, -15591, -14075, -4762, 6691, 15735, 19536, 17519, 10601, 3577, -186, 3532, 9039, 9400, 6665, 3618, 3736, 681, 1891, 4643, 1774, 2930, 13239, 22944, 24350, 25299, 22876, 9135, -3101, -4068, -1685, -840};