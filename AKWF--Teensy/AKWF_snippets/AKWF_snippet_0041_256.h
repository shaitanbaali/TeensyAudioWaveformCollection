/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0041 256 samples */
 
const int16_t AKWF_snippet_0041_256_DATA [256] = 
{1219, 5623, 8005, 10646, 16306, 18032, 17075, 16867, 18457, 19006, 17306, 14667, 12812, 10548, 9771, 9918, 9332, 10139, 8924, 6382, 4894, 4715, 6062, 4154, 136, -2391, -4177, -5376, -7926, -9989, -9216, -9236, -11326, -11179, -9278, -9757, -11903, -12874, -12314, -10663, -10516, -9529, -9332, -9161, -7045, -4986, -4424, -4127, -3696, -3235, -3211, -3197, -1412, 1023, 3918, 6604, 9301, 10465, 9860, 7811, 6195, 6600, 6295, 6415, 5589, 5294, 4127, 3065, 2887, 3135, 3077, 2907, 5107, 6401, 6362, 4824, 3950, 3022, 1193, 813, 1501, 823, -450, -1365, -3556, -6345, -6994, -5499, -2978, -756, -261, -1224, -2183, -3723, -5464, -6504, -7249, -7879, -8278, -8797, -8908, -8415, -7806, -8088, -7823, -8410, -8240, -6807, -4195, -2162, -2135, -1655, -844, 450, 1436, 2380, 3131, 3138, 2015, 1077, 402, 1554, 2573, 3395, 3852, 4580, 4515, 4673, 3657, 2315, 1153, 656, -556, -1046, -817, -1483, -2596, -3335, -2902, -3443, -2664, -2242, -1055, -78, 332, 1209, 2182, 2957, 2937, 2710, 1952, -202, 3465, 1264, 1054, 2021, 1054, 1163, 1167, 1387, 1494, 2505, 2181, 2811, 2780, 1886, 1323, 323, -536, 1817, -1445, -1557, -1775, -1849, -2220, -3666, -2430, -2994, -3648, -3002, -4918, -227, 2883, -1376, -558, -4295, 6380, 10021, -9988, 4702, 6666, 5633, -2381, 5005, 3609, 3103, 2713, 4044, 4188, -4660, -5614, -23, -8572, 28674, 11441, 10071, 2912, -1266, 14015, -2205, -6392, 1943, 9358, 9461, 9154, 5650, 14906, 5174, -10596, -535, 1763, 2265, 16136, 11251, 2734, 3836, -7382, -12728, -6062, -5873, -10011, -9716, -11592, -12584, -12329, -15356, -15877, -14055, -13305, -10432, -10524, -11512, -9408, -6154, -3119, 4513, 9279, 4679, 1055, -1191, -9425, -14047, -12731, -9089, -4595, -1912};