/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0002 256 samples */
 
const int16_t AKWF_snippet_0002_256_DATA [256] = 
{1212, 3201, 4613, 4839, 3881, 3540, 5574, 11113, 20014, 28119, 31761, 32369, 32023, 31692, 31981, 32500, 32796, 32068, 29732, 27328, 25550, 23331, 21258, 20702, 21765, 22847, 21889, 19410, 17340, 16280, 16429, 17312, 18328, 19772, 20751, 20291, 19473, 18813, 17799, 16532, 15336, 14263, 12576, 9954, 8121, 8047, 7801, 5831, 3066, -388, -6577, -13971, -18389, -20580, -22379, -22183, -21203, -21967, -23041, -22916, -21757, -19705, -17816, -16938, -16529, -15801, -14795, -14611, -15061, -14988, -15148, -16101, -17373, -19476, -21815, -23020, -23189, -22267, -20384, -18670, -16806, -14141, -11275, -8484, -5966, -4167, -2871, -1542, 639, 3575, 5872, 7616, 10143, 13243, 15973, 17865, 18627, 18601, 18320, 17899, 17050, 14969, 12165, 11013, 11463, 11143, 10390, 10616, 10779, 10086, 9356, 9129, 9685, 11035, 12904, 15025, 16281, 16066, 15362, 14096, 11849, 9955, 8818, 6802, 3003, -1439, -4868, -7554, -10156, -12054, -13678, -15382, -16026, -17017, -19783, -21951, -22722, -23199, -23075, -23282, -24254, -24320, -23849, -23509, -23104, -23836, -24330, -22087, -19573, -18776, -17887, -17034, -16953, -16433, -15840, -16353, -17528, -18878, -19814, -19713, -19368, -19119, -18305, -17772, -18169, -17843, -16202, -14800, -13989, -12778, -11163, -10463, -11097, -11492, -10559, -8962, -8762, -8867, 18710, 26389, 22099, 21174, 19378, 18017, 17332, 17092, 17130, 17463, 17976, 18015, 17099, 16290, 16447, 16363, 16008, 17474, 19987, 20966, 20880, 21112, 21244, 20146, 17029, 13128, 9720, 5430, 310, -3784, -7296, -10626, -12914, -14428, -15651, -17320, -19161, -18881, -16695, -15101, -13912, -12236, -10221, -7720, -5569, -4567, -3541, -2155, -1532, -1613, -1588, -1810, -2574, -2645, -1444, -560, -1328, -2796, -3758, -4750, -6182, -6880, -6570, -6392, -6462, -6134, -5331, -4629, -4580, -4681, -4141, -3117, -1955, -935, -389, -432, -819, -405};