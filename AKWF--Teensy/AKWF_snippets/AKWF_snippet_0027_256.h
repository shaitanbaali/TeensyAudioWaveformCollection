/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0027 256 samples */
 
const int16_t AKWF_snippet_0027_256_DATA [256] = 
{3704, 14505, 19845, 16853, 10912, 16874, 24729, 18743, 13401, 12937, 13480, 16585, 17495, 13996, 7717, 7790, 19060, 26209, 20789, 16103, 20390, 27533, 29004, 18971, 9924, 12695, 18285, 23259, 26757, 26133, 22701, 19126, 17822, 16772, 19309, 20015, 12376, 11253, 14170, 8762, 6572, 12815, 15079, 11263, 10737, 14826, 17731, 16671, 15955, 16541, 13176, 11873, 14618, 13673, 10355, 13636, 26763, 30423, 17050, 10595, 15143, 12179, 3945, 4080, 7245, 10646, 17730, 18897, 15522, 15693, 16243, 16613, 16254, 14566, 21524, 32274, 27180, 18432, 19149, 16817, 14030, 14924, 19317, 24332, 19288, 12101, 12300, 14758, 12431, 10370, 12892, 10748, 8363, 15275, 7631, -12793, -7711, -9938, -13250, -14197, -15989, -17578, -16121, -13871, -12879, -13048, -14243, -14692, -14642, -12731, -8723, -8607, -10491, -11775, -14347, -14648, -11704, -8779, -8278, -8811, -9821, -11229, -9116, -7052, -7294, -6679, -6452, -5680, -5077, -5911, -5848, -3633, -172, 502, -2122, -4613, -3893, 1176, 4411, 1586, -840, 2213, 4530, 1126, -2641, -2191, -850, -1627, -2088, -2785, -5417, -7681, -11199, -14794, -13277, -10251, -9626, -9910, -10403, -10128, -10881, -14061, -16050, -16353, -16693, -15690, -14313, -15489, -18086, -18283, -15170, -14352, -18227, -19514, -18935, -19935, -19330, -22724, -26371, -22518, -19314, -17995, -18889, -22196, -21759, -21465, -21731, -17532, -12721, -13816, -16652, -15430, -16771, -18646, -14756, -9042, -4680, -5029, -8383, -8584, -7265, -10975, -15733, -11500, -5598, -5788, -6796, -7353, -8633, -8579, -4584, -1398, -3018, -3232, -2950, -5349, -6603, -8613, -10865, -7212, -3116, -2846, -4505, -12367, -18094, -14323, -12657, -11945, -7667, -10115, -15495, -12816, -7608, -3089, 1462, 28, -6882, -12266, -11776, -9005, -8582, -8538, -10162, -9117, -3927, -4369, -7690, -9641, -6600, 1535, 3933, 4694, 8136, 9251, 5937, 250};