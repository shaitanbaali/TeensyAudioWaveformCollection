/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0020 256 samples */
 
const int16_t AKWF_snippet_0020_256_DATA [256] = 
{1353, 3584, 4053, 3996, 4697, 5956, 7185, 8099, 9058, 9834, 9531, 8788, 9001, 8938, 7480, 6999, 7925, 8057, 8343, 9678, 10337, 11149, 13320, 14597, 14441, 14759, 15538, 15873, 15816, 15513, 15016, 14657, 15214, 16166, 15627, 14276, 14169, 14910, 15536, 15516, 15670, 17546, 19143, 19077, 19454, 19829, 18825, 15833, 12107, 11676, 10533, 5011, 4669, 8443, 4693, -2169, -6260, -9759, -10854, -9817, -9533, -10664, -13094, -13617, -12639, -12461, -12967, -2627, 7968, 5792, 6565, 5931, 6440, 8023, 7779, 7917, 9130, 8936, 9380, 11390, 11865, 11308, 11446, 10955, 9697, 9035, 8547, 7360, 6265, 5371, 3740, 2300, 1615, 120, -1710, -2373, -2458, -2153, -761, 1044, 1673, 541, -500, -129, 240, 423, 1444, 2772, 4060, 5242, 5852, 6282, 6789, 7374, 8406, 9247, 9108, 8704, 8851, 8833, 8385, 9153, 10777, 10904, 10836, 12729, 15058, 16682, 17834, 18526, 19442, 20137, 19739, 19350, 19231, 18769, 18524, 18133, 17126, 16398, 15379, 13486, 12028, 10744, 9038, 8382, 8154, 6449, 4744, 4472, 4391, 3909, 3034, 743, -2076, -3383, -5201, -9498, -12940, -14610, -17449, -20401, -21942, -23960, -26399, -27898, -29054, -30008, -30858, -32318, -32652, -30679, -29830, -30794, -29862, -28121, -28154, -27910, -26583, -25060, -23839, -24001, -24045, -23106, -22931, -22190, -20789, -21141, -21057, -19139, -18480, -19262, -18896, -17618, -17667, -18079, -16841, -15812, -15851, -14868, -12552, -10013, -8184, -6527, -3636, -1051, -173, 73, 300, 1455, 2717, 2180, 2501, 4251, 3556, 1944, 2526, 2512, 545, -574, -1392, -3418, -4627, -5350, -6977, -6889, -5588, -6343, -7609, -7655, -7595, -7769, -7915, -7733, -7694, -7784, -6890, -6394, -7008, -6812, -6450, -7112, -8252, -9266, -9057, -8141, -7166, -5385, -4501, -4514, -2938, -1506, -901, 454, 506, -203};