/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0038 256 samples */
 
const int16_t AKWF_snippet_0038_256_DATA [256] = 
{988, -1914, -640, 3233, 5649, 5697, 5590, 6332, 6809, 5908, 6707, 8604, 8329, 9892, 9901, 11360, 11173, 11337, 12334, 12348, 14214, 14010, 13489, 13834, 16948, 16604, 16088, 17525, 15593, 12000, 15008, 16294, 14987, 16653, 15786, 13393, 14275, 15394, 17136, 15109, 14109, 16162, 17748, 15249, 15941, 17405, 18780, 21095, 18363, 15965, 16250, 15799, 19212, 18620, 18215, 21058, 21133, 23565, 24429, 24772, 25516, 25918, 26254, 27644, 29088, 29095, 29183, 28163, 27069, 29757, 29291, 29428, 29525, 28837, 27397, 28402, 29605, 28703, 28682, 26911, 26073, 25784, 24467, 24229, 24400, 22642, 20533, 19762, 17970, 19921, 16648, 16157, 16121, 15672, 18718, 20381, 17800, 16259, 15088, 16275, 17009, 15024, 12939, 16642, 15976, 14484, 13686, 13768, 16744, 15010, 15107, 15615, 13243, 12298, 17235, 16420, 15756, 15762, 15481, 13002, 12864, 13539, 12893, 11800, 11336, 10082, 11320, 9997, 9507, 9090, 7362, 5488, 3453, 4910, 6876, 5015, 5435, 4533, 4732, 2087, -1815, -2891, 345, -583, -3031, -3943, -2836, -4868, -9846, -10182, -9021, -12492, -14074, -15524, -16315, -16856, -15593, -12385, -14841, -17461, -18558, -20022, -19538, -20371, -20055, -21259, -21029, -19807, -18915, -20352, -18619, -18739, -20237, -18935, -18267, -21468, -22554, -22626, -21743, -25072, -24963, -24569, -24782, -25241, -26570, -29398, -25544, -26653, -27248, -30710, -32487, -31175, -30691, -29710, -29557, -28294, -25981, -26805, -28820, -30681, -29185, -27279, -25668, -27575, -29505, -29862, -30739, -31237, -31449, -30584, -27642, -26293, -25544, -28822, -26077, -25021, -24842, -23391, -24142, -25009, -21641, -21913, -21987, -20997, -17313, -18936, -20289, -18588, -18300, -18869, -18371, -19442, -21055, -21151, -19722, -20142, -18750, -19414, -18171, -16815, -14826, -12510, -15083, -16287, -15840, -15323, -13068, -12131, -9140, -9452, -8975, -4985, -2216, -2960, -2327, -579};