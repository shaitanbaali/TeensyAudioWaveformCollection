/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0004 256 samples */
 
const int16_t AKWF_snippet_0004_256_DATA [256] = 
{2345, 16532, 13271, 10270, 6369, 7382, 10265, 14886, 18112, 21492, 26193, 30526, 31837, 28347, 25419, 25819, 28229, 25978, 23263, 21708, 19278, 19184, 21772, 23961, 25575, 24533, 19705, 15544, 12540, 15015, 22304, 24389, 21697, 20828, 19683, 16581, 11442, 6604, 5918, 9392, 12809, 12136, 8055, 5979, 12024, 18573, 16203, 6065, -3465, -11062, -13435, -16441, -15892, -15702, -9149, -5803, -2653, -9386, -14740, -16890, -17167, -20229, -23476, -28560, -30601, -30524, -28826, -23916, -22132, -21657, -23111, -25825, -27529, -26423, -25910, -24665, -23104, -23108, -22631, -22617, -22337, -22231, -22016, -20537, -20902, -18460, -18582, -17366, -11821, -3245, 432, -5132, -13218, -16086, -17145, -16678, -15675, -12856, -7755, -2100, 2784, 3058, 747, 2629, 5164, 3883, 3222, 3877, 1836, 3277, 7898, 9767, 12128, 13308, 8749, -532, -7247, -7198, -1011, 6509, 8480, 5084, 1744, 5371, 15437, 19237, 10310, -315, -4336, -4244, -4231, -6173, -7989, -4806, 5192, 11932, 9642, -901, -6737, -1398, 4365, 4818, 191, -5642, -7730, -3190, 2033, 4596, 3858, 994, -310, -596, -841, 1876, 6357, 7530, 8616, 9094, 6993, 669, -6277, -7996, -3253, 4961, 8712, 3053, -2890, -1469, 8772, 14554, 7683, -2721, -6232, -5431, -6649, -10469, -12927, -10620, -2093, 5174, 6518, 510, -2432, 5131, 13884, 16437, 14422, 9669, 6536, 8489, 13252, 14615, 14853, 14452, 14980, 12772, 7388, 7137, 13622, 16695, 17855, 15022, 9540, 2825, -2589, -3870, -4724, -1414, 2259, 1249, -2865, -4725, 2354, 7629, 794, -6881, -18861, -18402, -22612, -19774, -21693, -16476, -12714, -2820, -270, 190, -1531, 4395, 14900, 18773, 20204, 20327, 14855, 13074, 12917, 3516, -2583, -10472, -17517, -20816, -23246, -19342, -14877, -14612, -16292, -16119, -14497, -18659, -20878, -22445, -21441, -14175, -7785, -7761, -7069, -6778};