/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0003 256 samples */
 
const int16_t AKWF_snippet_0003_256_DATA [256] = 
{2294, 4412, 4642, 8124, 13076, 19839, 21185, 22176, 17171, 13821, 16860, 21884, 25134, 22452, 20923, 16402, 17865, 21478, 25373, 27494, 27828, 28122, 25367, 27616, 25585, 27167, 28487, 30857, 32461, 30866, 30563, 28419, 28206, 25770, 24670, 20086, 20447, 26513, 26986, 26665, 26117, 26254, 25206, 24794, 24707, 24713, 24528, 22652, 19904, 18077, 23187, 23252, 22253, 22633, 22155, 22755, 21539, 20938, 21239, 20325, 17102, 19806, 20293, 16450, 12372, 6045, 6744, 3852, 7576, 10290, 11845, 9973, 5878, 1423, -3588, -1059, -1800, 4246, 5636, 2132, -2271, -4518, -4006, -7221, -7849, -14708, -16592, -15969, -11212, -9641, -11346, -11816, -15864, -10864, -3744, 1618, -6310, -15003, -22348, -26590, -25668, -25147, -22917, -23026, -20508, -21493, -17190, -11881, -11995, -12448, -15225, -18731, -23875, -24378, -24204, -25153, -25994, -24902, -25225, -22569, -15398, -12312, -14642, -19009, -22300, -22967, -19423, -14391, -9461, -10350, -13619, -18324, -18240, -15242, -14740, -15241, -18863, -19980, -17853, -13873, -11958, -12193, -13127, -11848, -3691, 4599, 6664, 748, -6790, -13019, -13688, -11472, -8416, -5796, -3462, -1365, 1162, 4094, 7252, 9495, 9669, 11173, 10059, 5234, 46, -3597, -2639, -1570, 232, 1625, 8006, 15654, 18378, 18839, 12888, 6087, 2354, 10014, 18227, 20230, 15787, 6927, 3686, 6739, 14979, 16134, 14827, 10657, 7603, 10569, 12979, 13992, 10758, 11238, 15661, 22939, 27764, 23794, -14317, -19223, -14959, -17719, -23614, -26558, -27982, -27862, -26715, -26187, -25640, -24600, -22067, -18321, -18822, -18902, -20866, -22730, -22078, -21610, -21155, -21186, -20437, -19978, -19407, -19599, -19732, -19327, -18511, -18341, -17465, -17337, -17893, -17455, -16939, -15574, -10053, -8596, -8845, -11131, -14863, -16020, -16480, -15904, -14946, -11211, -7362, -4535, -3437, -2457, 741, 4755, 11152, 10394, 5336, -1391, -2287, 79};