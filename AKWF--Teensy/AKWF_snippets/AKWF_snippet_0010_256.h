/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0010 256 samples */
 
const int16_t AKWF_snippet_0010_256_DATA [256] = 
{5203, 10544, 23592, 27949, 22918, 21086, 26629, 20480, 17045, 24527, 30109, 31436, 29443, 26459, 24526, 22022, 20808, 21771, 26773, 25327, 24474, 23799, 23205, 20721, 19378, 20230, 17843, 14636, 12538, 14841, 19716, 16225, 6028, 5616, 5223, -1701, -8307, -8585, -10958, -1398, -386, -8250, -14493, -3665, -3600, -15132, -17438, -20519, -20155, -25860, -24121, -26700, -20226, -20182, -24791, -21376, -25871, -19028, -21645, -9804, 5656, 3875, 5394, -2860, -17045, -22251, -12628, 3314, 10342, 9733, 3138, 6964, 14555, 11440, 10991, 8507, 8505, 12019, 9526, 6012, 4633, 1827, 4860, 4337, 134, -6380, -11596, -13502, -10132, -21200, -21324, -19546, -6174, 818, 4966, 18048, 19925, 18396, -74, -15088, -21058, -22576, -19161, -12756, -8209, -6954, -13334, -19065, -19419, -15129, -9772, -6963, -324, 10631, 18360, 22027, 21201, 13110, 11107, 11424, 12067, 21873, 27694, 25686, 21180, 19208, 19103, 13543, 5315, 9101, 16698, 20995, 15163, 5826, 1993, 2748, -2595, -4493, -3753, 1775, 4105, -1713, -8238, -13378, -19435, -14560, -17417, -19620, -15566, -13561, -15508, -21216, -26198, -28174, -27173, -24786, -23156, -17597, -18913, -21801, -19927, -20800, -19989, -17339, -12874, -7939, -7802, -10406, -6438, -7948, -10292, -10062, -6298, 3369, 7069, 9752, 16119, 18212, 19083, 14073, 13858, 18284, 21179, 24969, 27008, 30968, 30847, 28741, 27280, 27275, 26602, 25128, 18439, 21371, 23254, 22948, 22197, 21402, 21181, 20723, 14057, 6725, 4840, 9672, 16593, 14752, 13703, 11649, 6385, -706, -9996, -14325, -12589, -9740, -6378, -10701, -10141, -12219, -15992, -20095, -23269, -27905, -24881, -22265, -26339, -27250, -28911, -26769, -24912, -25038, -24307, -14564, -14261, -17983, -22763, -22343, -21853, -21215, -20974, -18880, -13684, -10878, -13669, -16945, -18634, -18484, -17453, -13126, -2159, 5069, 5379, 5179, 4695, 4814, 1944, 1202};