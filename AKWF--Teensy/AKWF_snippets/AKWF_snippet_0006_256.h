/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0006 256 samples */
 
const int16_t AKWF_snippet_0006_256_DATA [256] = 
{1485, 2280, 4668, 9993, 17777, 20094, 20339, 13609, 13087, 17736, 23616, 21687, 19536, 14835, 16958, 21083, 25587, 26305, 27380, 24532, 26032, 24523, 26323, 27834, 31084, 30608, 29664, 27843, 26978, 24627, 22785, 17723, 21889, 26072, 25587, 25026, 25043, 23981, 23534, 23381, 23620, 22340, 19474, 13591, 18663, 19522, 17005, 16471, 15140, 12015, 6938, 3183, 3392, 7293, 9393, 8076, 4237, 3706, 10230, 14684, 10878, 1440, -7233, -12976, -15098, -17119, -17056, -15377, -10027, -6642, -5275, -11956, -16595, -17588, -18351, -20806, -25024, -28441, -30262, -29482, -28230, -22836, -22488, -21800, -24035, -25910, -27381, -25907, -25695, -24268, -23359, -23066, -22890, -22651, -22585, -22400, -22006, -20854, -20966, -18816, -19144, -17334, -11512, -3832, -2323, -8636, -15215, -16975, -17895, -17155, -16356, -12996, -8268, -3121, 611, 207, -1574, 669, 2392, 1209, -1364, -1519, -1722, -1257, 2884, 10012, 16679, 20719, 18458, 16040, 12969, 16471, 22342, 26952, 24482, 22500, 25608, 28158, 27570, 25977, 25051, 26630, 29096, 29872, 28487, 28162, 27141, 26735, 26348, 25657, 24851, 24682, 22686, 20210, 20666, 22025, 23172, 22615, 22529, 22629, 21602, 20550, 20265, 20503, 19074, 17428, 15693, 12958, 10988, 12955, 17426, 18693, 18107, 12145, 5933, 3281, 6497, 8898, 4769, -1400, -4091, -2706, -2407, -4798, -8438, -10243, -8155, -8194, -9193, -14008, -14078, -9313, -2144, -6500, -13065, -19045, -23529, -26459, -27292, -26716, -22750, -21973, -21976, -21445, -20867, -21345, -18063, -23005, -28599, -31002, -31614, -30516, -29710, -29043, -27830, -24020, -21234, -22295, -22940, -26049, -25431, -24818, -24446, -24270, -23410, -22862, -22623, -22993, -22511, -21657, -21371, -20363, -20752, -20877, -20113, -19202, -13350, -11199, -11782, -15294, -18629, -19365, -19241, -18254, -14436, -9858, -6642, -6005, -3496, 244, 7551, 9249, 3596, -3936, -4254, -2089};