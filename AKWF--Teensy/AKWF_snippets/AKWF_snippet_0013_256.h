/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0013 256 samples */
 
const int16_t AKWF_snippet_0013_256_DATA [256] = 
{1406, 2855, 1786, 1458, 4165, 2127, 5617, 5127, 9287, 7239, 12015, 10882, 12743, 9933, 14457, 14315, 10696, 16283, 16045, 16664, 21402, 18920, 23040, 26648, 23075, 21886, 28728, 28148, 30068, 29452, 31752, 31190, 30955, 32232, 30980, 32131, 31545, 30909, 29716, 29112, 29469, 28663, 27973, 28159, 26695, 26873, 25897, 26315, 26506, 25631, 24756, 24204, 24630, 23666, 23663, 23538, 23660, 22693, 22995, 21786, 21440, 20774, 20656, 20149, 19362, 17473, 15996, 17690, 16293, 17047, 14226, 14322, 16048, 17289, 20222, 17389, 11313, 12004, 10274, 11253, 13192, 3951, 894, -1525, -4381, -4213, -4043, -6297, -9183, -10269, -13586, -13978, -16766, -17928, -14815, -20073, -20529, -22332, -24066, -22661, -21957, -24117, -23339, -24752, -24573, -25248, -24692, -23329, -24251, -23378, -23521, -22654, -22155, -21774, -21642, -20297, -19932, -20386, -19464, -19659, -17213, -19192, -19551, -18208, -17841, -18513, -18089, -17943, -18862, -18133, -17299, -16745, -17694, -16985, -16940, -16299, -16608, -16114, -15598, -15661, -15221, -15727, -14614, -14300, -13948, -13676, -13241, -13101, -12949, -9502, -8832, -6624, -4193, -2183, 321, 480, 2461, 2865, 5570, 6219, 6868, 5328, 6025, 7496, 8159, 10732, 11619, 11091, 13154, 12287, 16093, 13372, 8205, 10312, 6403, 8996, 7797, 6192, 5296, 7326, 4543, 6336, 3755, 3981, 3414, 3623, 1594, 699, 1055, 1828, 1753, 2370, 3808, 3393, 1723, 2448, 727, 3238, -1169, -201, -1117, -4746, -2402, -2404, -1484, -4118, -7649, -4151, -5307, -12959, -10443, -13252, -15417, -14695, -14697, -17386, -17574, -21439, -20635, -17602, -22051, -20772, -19491, -20368, -19859, -20240, -19450, -18659, -18553, -17959, -17109, -16843, -16542, -15654, -15493, -15396, -14976, -14025, -14617, -14318, -13310, -12650, -12137, -11819, -8401, -8385, -7814, -6947, -4445, -1730, -3537, -2393, -633, -3505, 2921, -1542};