/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0015 256 samples */
 
const int16_t AKWF_snippet_0015_256_DATA [256] = 
{7195, 14738, 15914, 19399, 23752, 24075, 20623, 15650, 18289, 21400, 17723, 20211, 21796, 17383, 18327, 19827, 16891, 15258, 12756, 7465, 6248, 2322, 2622, 9081, 19239, 21138, 18376, 9901, 6175, 11257, 17303, 19613, 22599, 21331, 17274, 17507, 16896, 14637, 12393, 11956, 11286, 7094, 7699, 14491, 17533, 18534, 20241, 21468, 20149, 20686, 18502, 18988, 17972, 17688, 17108, 16245, 14029, 13954, 12609, 12565, 10639, 6244, -2819, -10604, -9900, -16913, -25247, -29809, -31954, -32644, -31323, -28957, -28272, -25828, -25591, -23955, -25394, -23337, -21317, -23278, -22825, -20750, -20700, -20393, -15597, -14334, -15570, -18098, -18674, -19453, -21308, -23406, -21776, -20875, -22360, -18864, -12110, -12870, -8537, 3146, 6530, 5979, 11143, 14509, 15171, 17100, 17774, 20569, 20378, 19253, 20373, 19141, 17264, 15683, 12902, 10699, 8062, 2943, 203, -1486, -3627, -4500, -3187, -1830, -1406, 2060, 5078, 4460, 2060, 4403, 5917, 3595, 1568, 1849, 1403, 1320, 3790, 5352, -1200, -5928, -9703, -7200, -20255, -30169, -23969, -22657, -25235, -31338, -27379, -29027, -30549, -28396, -24390, -25036, -24640, -21773, -22353, -22013, -21073, -19216, -18628, -18868, -16043, -16788, -16674, -18179, -16952, -19155, -19366, -20072, -16496, -17316, -12629, -8523, -6496, -9777, -3347, 6547, 11618, 7652, 10020, 12635, 19074, 15649, 17037, 19810, 23153, 19169, 18028, 21765, 24028, 22560, 19616, 18805, 19525, 15222, 13920, 11951, 11541, 10419, 11129, 9553, 7124, 14187, 18957, 18016, 16237, 16367, 17850, 17101, 13015, 12947, 15615, 8906, 13408, 15095, 12060, 6926, -2624, 3771, 1649, -11228, -16421, -20094, -20524, -26374, -28193, -27248, -26168, -22940, -19359, -16012, -16693, -13870, -9152, -10730, -11868, -10083, -10818, -10519, -7005, -6912, -5744, -983, 4960, 1786, 5564, -915, -1515, 1498, -7632, -9678, -3774, -4193, -6639, -241};