/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0028 256 samples */
 
const int16_t AKWF_snippet_0028_256_DATA [256] = 
{2275, 4948, 3187, 6725, 14239, 17761, 23122, 22013, 17481, 19166, 23242, 21245, 23188, 28996, 32737, 27134, 16508, 22480, 28804, 26417, 27688, 28274, 29870, 26533, 22973, 23238, 26055, 29835, 26319, 17015, 13723, 17302, 21947, 22328, 26087, 22916, 17663, 18819, 20908, 17159, 21103, 21972, 14378, 6606, 10099, 14296, 9114, 5177, 2792, 7878, 16221, 17041, 16287, 17023, 10190, 8335, 12294, 15901, 19599, 23196, 21596, 12137, 10836, 11555, 8677, 8883, 4686, 7509, 15934, 14510, 3654, 9500, 17271, 3889, -9460, -3023, 11363, 12724, 10697, 10385, 9243, 7432, -521, -616, 3615, -1025, -13203, -19086, -16551, -9736, -10521, -9918, -7365, -10711, -14710, -6073, -2217, -9860, -8685, -8752, -14343, -8058, 186, -2579, -8903, -15759, -14251, -12937, -11238, -1501, -2320, -7662, -8148, -4639, -1145, 2208, 6059, 5216, -3045, -5735, -1673, -1642, 2600, 7243, 7844, 8373, 10893, 11774, 8192, 8517, 11412, 10096, 14028, 19223, 15255, 13384, 16220, 13491, 12048, 16987, 14940, 10614, 12294, 15405, 10856, 9232, 12137, 13593, 9304, 6914, 7657, 6273, 3833, 4884, 6163, 4563, 2410, -6185, -1722, 1375, -92, -998, -93, -606, 781, 996, 1090, -1047, -3815, -4365, -1995, -1550, -4293, -4475, -2039, -4147, -4574, -4370, -5632, -7272, -8652, -10708, -12229, -11418, -11738, -12537, -11815, -11002, -12960, -15206, -15090, -17095, -19462, -21602, -22208, -21964, -23033, -22878, -17324, -15228, -21719, -24160, -22147, -21199, -18436, -16861, -17259, -17530, -17599, -21858, -26341, -20442, -15250, -19028, -22739, -23780, -23380, -25082, -22379, -21527, -24948, -25832, -23077, -18819, -20408, -19442, -19398, -26764, -27059, -16667, -13196, -18506, -24174, -29385, -27427, -24270, -19909, -17149, -18464, -19029, -23222, -21788, -19299, -19564, -17461, -12971, -14655, -13732, -7578, -3741, -8560, -10203, -5644, -471, -3861, -3767};