/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0005 256 samples */
 
const int16_t AKWF_snippet_0005_256_DATA [256] = 
{2616, 3408, 4616, 8256, 13978, 19999, 20911, 21793, 16535, 13180, 16238, 20732, 25131, 22394, 21256, 16946, 16101, 20177, 23179, 27239, 26988, 28613, 26293, 25856, 27280, 25034, 27906, 28444, 31552, 32251, 30693, 30474, 28163, 28156, 25640, 24623, 20491, 19020, 25422, 26929, 26624, 26011, 26031, 25594, 24504, 24610, 24324, 24622, 23606, 21686, 18395, 18455, 23701, 22378, 22174, 22187, 21857, 22434, 21277, 20523, 20860, 20346, 17093, 18076, 20835, 16866, 14194, 7138, 5344, 4732, 3483, 8810, 9800, 11445, 7769, 4334, -988, -4709, -1950, -2896, 3661, 4809, 1207, -2674, -6129, -4533, -8345, -8349, -13925, -18482, -17562, -15694, -10133, -12746, -12097, -15375, -16618, -9725, -2889, 119, -9971, -17478, -25110, -28394, -27508, -27010, -24682, -24923, -22345, -23057, -20437, -13863, -13468, -13320, -15743, -18368, -23513, -26512, -25846, -26348, -27473, -27620, -26587, -27060, -22919, -15962, -13796, -16427, -20838, -23971, -24830, -21444, -16627, -11326, -11104, -14078, -18601, -20675, -17657, -16313, -16138, -18506, -21534, -21057, -18067, -14138, -13500, -13629, -14795, -12312, -3597, 4152, 5785, -236, -7637, -14075, -15350, -13265, -10473, -7547, -5327, -3104, -956, 1975, 4877, 7983, 8905, 9457, 10756, 7917, 2825, -2193, -4872, -3476, -2465, -658, 776, 7201, 14960, 17648, 18786, 13509, 6767, 1419, 6078, 15698, 19721, 18197, 10163, 3562, 3371, 9391, 16049, 15027, 13616, 8659, 7107, 10505, 12566, 13333, 9959, 10645, 14868, 22099, 26706, 27840, -13800, -28564, -21634, -19495, -20977, -20331, -23431, -24306, -23826, -23276, -22879, -22923, -22180, -21711, -21153, -21157, -21481, -21142, -20401, -19992, -19576, -18723, -19355, -19441, -18626, -18544, -15185, -10360, -10057, -10390, -13373, -16736, -17626, -18089, -17423, -16529, -12930, -8886, -6244, -4438, -4302, -928, 1955, 8669, 10775, 7174, 477, -3911, -2159, -584};