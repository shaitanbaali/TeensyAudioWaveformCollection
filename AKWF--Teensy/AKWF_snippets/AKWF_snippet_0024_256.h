/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0024 256 samples */
 
const int16_t AKWF_snippet_0024_256_DATA [256] = 
{2980, 10876, 15778, 18819, 20804, 20871, 16986, 10632, 6856, 6364, 2254, 93, 1550, 3171, 1448, 948, 1753, 3046, 4130, 213, -4510, -4039, -2421, -942, 3560, 7415, 10779, 10670, 9418, 13174, 12409, 9945, 5289, -139, -3968, -8743, -8068, -6259, -11269, -16643, -14794, -14103, -20103, -16522, -15502, -8683, -5668, -5030, -3387, -1865, -849, 2653, -419, 4237, 3472, 6131, 9629, 7738, 8899, 14440, 9446, 11607, 15806, 11715, 11657, 6449, 5591, 5661, 690, -93, -3235, -1595, 1582, 1534, 3784, 7291, 12324, 10658, 13514, 16763, 21105, 16377, 12094, 10814, 3993, -2703, -6864, -4428, -5378, -6161, -330, 5383, 4626, -45, 34, -2045, -12646, -21309, -22506, -19865, -14431, -8802, -5221, 1160, 5732, 9543, 8050, 2022, -3542, -11707, -16745, -20580, -17896, -16008, -14211, -8465, -1886, 3134, 2810, 626, 1194, 61, 52, -1733, 633, 4211, 9676, 13850, 20570, 24749, 24168, 21470, 12054, 4775, 216, -3400, -1616, 265, -1376, 1007, 3597, 6435, 5459, -2091, -2329, -2263, -13470, -14148, -13690, -8544, 3308, 10048, 11723, 13199, 12159, 8726, 5002, -380, -4372, -6442, -4978, -4494, -193, 202, -65, -2210, -1865, -3183, -11276, -16884, -16906, -16373, -14352, -8395, -5823, -824, 3912, 7932, 11992, 15167, 17908, 12384, 4710, -580, -7662, -4921, -2092, -2958, -2436, 2100, 6430, 9772, 3186, -5382, -5671, -7632, -2865, 2096, 3872, 15496, 21319, 12239, 9100, 4976, 44, -10699, -12091, -4464, 7132, 6527, 9903, 5249, -8238, -23571, -29872, -27546, -22791, -4957, 935, 12441, 313, -11638, -9154, -10270, -8502, -9761, -14862, -16473, -13383, -13271, -12250, -9279, -9128, -9058, -8311, -2022, 2001, 2008, -971, -5293, -6550, -6762, -7471, -631, 1192, -659, 1060, 5251, 6574, 3256, 775, 1356, 233, -7031, -5474, -1372};