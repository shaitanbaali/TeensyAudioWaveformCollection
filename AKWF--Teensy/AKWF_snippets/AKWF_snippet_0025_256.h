/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0025 256 samples */
 
const int16_t AKWF_snippet_0025_256_DATA [256] = 
{2582, 4353, 5540, 7551, 9597, 14579, 19086, 19266, 16224, 9049, 6332, 12456, 22302, 21134, 10786, 3172, 1127, 7032, 17720, 18445, 10970, 6144, 3717, 2786, 4599, 789, 3400, 6750, -817, 851, 9312, 6028, -3367, -1818, 7323, 12340, 11308, 11240, 12782, 15207, 15514, 15172, 12639, 7892, 3307, 2487, 2542, 4094, 2620, -2549, -2957, -3595, -6266, -7637, -10582, -5501, 564, -2952, -12596, -20907, -22990, -17682, -14801, -26374, -12131, 22260, 21993, 21842, 18896, 18933, 15060, 9917, 9905, 8186, 7591, 8980, 9810, 5323, -777, -5227, -4941, -417, 1836, -3797, -17817, -24159, -13390, -1550, 5393, 2905, -6073, -9095, -7845, -7188, -6243, -6773, -9767, -11557, -12722, -12588, -9589, -4223, 163, 1209, -343, -1849, -4509, -2390, 1521, -1387, -5495, -6288, -5839, -4744, -1599, -1997, -7269, -8603, -4989, -1130, 2125, -2106, -14042, -20559, -16114, -6946, 2631, 4365, -1790, -5286, -1687, 7045, 12900, 8888, 3275, 3682, 8850, 18007, 21495, 15223, 8253, 5186, 3710, 5564, 8565, 8030, 2759, 249, -1218, -4942, -3468, -1160, -3662, -8876, -10760, -9259, -5701, -3421, -7270, -14425, -18333, -16661, -14573, -11510, -5239, -4495, -7586, -6711, -1972, 6042, 8416, 876, -6641, -5581, 1615, 8057, 9061, 4126, -46, 3232, 10697, 17331, 16970, 11515, 8148, 9767, 12920, 12765, 10050, 6825, 3740, 339, 628, 4677, 4011, 2464, 3692, 1641, -594, -1196, -4445, -6996, -9895, -13531, -11463, -4981, 975, 5006, 2784, -5201, -10507, -10365, -4836, 1774, 3328, 166, -5392, -6381, -25, 6698, 5002, -2905, -7060, -1803, 5917, 9542, 6386, -3105, -8310, -4428, -480, -747, -4253, -7006, -6874, -3665, -2259, -6850, -13963, -16880, -18091, -18829, -14391, -9731, -10316, -11720, -11483, -7268, -5106, -8631, -10903, -9472, -8011, -6137, -3088, -663};