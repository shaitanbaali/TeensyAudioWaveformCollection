/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0011 256 samples */
 
const int16_t AKWF_snippet_0011_256_DATA [256] = 
{1157, 3673, 5827, 8206, 11200, 15805, 20494, 20791, 21951, 19191, 17970, 15950, 17600, 18964, 19406, 18439, 13281, 11049, 8186, 6255, 3781, 1746, 2728, 3180, 3356, 1561, 881, -1018, -1570, -1838, -684, 2202, 3131, 4254, 3843, 2291, 652, 473, 299, 2621, 2725, 3976, 4090, 5125, 5616, 2201, 1559, -2258, -1789, -3111, -862, 1172, 6940, 10779, 12307, 9340, 10386, 10173, 12062, 14525, 13336, 16628, 15046, 15263, 13285, 11287, 13076, 11493, 13025, 9527, 6073, 2510, -4128, -6380, -11849, -10781, -13145, -11477, -13187, -14441, -14858, -14620, -21473, -22968, -27570, -23891, -22932, -19352, -15882, -14177, -9008, -12709, -8894, -9199, -2708, 655, 5010, 6267, 8641, 9598, 12163, 11517, 6310, -535, -6214, -11631, -16165, -18731, -15189, -12848, -13469, -17909, -21127, -21973, -21601, -20984, -20366, -15101, -9064, -4785, -955, 451, 801, -325, -3554, -2749, 349, 4123, 8346, 9440, 11056, 10422, 7899, 7643, 7703, 9109, 9304, 9534, 11537, 14551, 13062, 11347, 9421, 8808, 11015, 11781, 14938, 16729, 18917, 18646, 14787, 13152, 11753, 10435, 10999, 9642, 10570, 11487, 10987, 9080, 5228, 1367, -3260, -2929, -1023, 1538, 2008, 752, -515, -2166, -1683, -3785, -4753, -4296, -1060, -53, 6261, 5426, 9221, 6549, 4312, 3602, 4626, 6667, 7147, 6901, 6701, 8889, 6064, 7661, -2816, -1191, -5375, -2553, -1442, -181, 465, -71, 40, -4622, -3538, -4925, -1622, -1121, 12133, 17008, 20413, 14145, 9497, 3525, -1955, -4227, -4857, -503, -1097, -6924, -17060, -21833, -25474, -28962, -32516, -32292, -29761, -23866, -21509, -19456, -21204, -24005, -26918, -26271, -19231, -11187, -4654, -1554, 1753, 3317, 323, -5770, -9364, -8433, -5910, -4539, -2479, -1031, -687, -4557, -10700, -14883, -16168, -13774, -10972, -7577, -3426, -891, -1155, -526};