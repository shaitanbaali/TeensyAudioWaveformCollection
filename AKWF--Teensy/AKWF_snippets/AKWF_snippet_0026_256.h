/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0026 256 samples */
 
const int16_t AKWF_snippet_0026_256_DATA [256] = 
{14061, 26982, 18633, 18391, 17808, 16600, 15289, 14486, 14408, 14995, 15850, 16466, 16613, 17004, 18010, 19236, 19927, 19951, 19104, 17242, 14691, 12545, 11321, 10488, 9011, 6437, 2944, -678, -3537, -5101, -5387, -4731, -3305, -934, 2237, 5433, 7564, 8334, 7570, 4875, -119, -6302, -12157, -16921, -20450, -22111, -21699, -19821, -17162, -13333, -8522, -4295, -2682, -4432, -9239, -15977, -22532, -26911, -28482, -28021, -26444, -24749, -23450, -22023, -18852, -14052, -9715, -8124, -9086, -11169, -12888, -13692, -14043, -15125, -17396, -19946, -21732, -22900, -23743, -23604, -21928, -19738, -18564, -18665, -18881, -18266, -16761, -14979, -13519, -12638, -12277, -12283, -12512, -12739, -12786, -12664, -12395, -12009, -11637, -11521, -11329, -10414, -8441, -5945, -3491, -1273, 780, 2557, 3751, 3744, 2175, -327, -2093, -2110, -974, -277, -849, -2339, -3591, -3458, -1685, 780, 2684, 4034, 5543, 6974, 6915, 4747, 1749, -435, -1131, -680, 454, 1657, 2209, 1967, 1638, 2020, 3188, 4639, 5871, 6575, 6693, 6433, 6107, 6171, 7115, 9053, 10851, 10808, 8147, 3805, -899, -5151, -8560, -10384, -10439, -9286, -7683, -5530, -2232, 2501, 8277, 13541, 16360, 15880, 13291, 10350, 7559, 4555, 1639, -172, -421, 737, 3557, 8493, 14704, 20102, 23038, 23594, 22735, 21011, 18302, 14601, 10412, 6555, 3850, 3175, 5008, 9007, 13848, 18391, 22204, 25264, 27222, 27761, 27014, 25444, 23045, 19805, 15900, 11911, 8381, 6094, 5554, 6473, 7881, 9565, 11824, 14579, 16763, 17724, 17488, 16503, 15139, 13725, 12274, 10334, 7737, 4830, 2142, 28, -797, 6, 1701, 2666, 2492, 1817, 1358, 1015, 763, 562, 341, 89, 95, 78, -622, -2075, -3535, -4945, -7094, -10193, -13206, -15447, -17049, -18113, -18366, -17949, -17475, -17053, -16558, -16421, -17672, -19462, -29023, -26210};