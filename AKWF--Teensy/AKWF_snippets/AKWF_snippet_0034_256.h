/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0034 256 samples */
 
const int16_t AKWF_snippet_0034_256_DATA [256] = 
{1262, 5778, 18585, 30713, 29711, 24923, 18059, 5878, 5483, 5720, -1776, 3874, 1109, -8528, -6029, -2047, 2633, 6080, -131, 144, -511, -1481, 1789, -2476, -12348, -12496, -22109, -22705, -18319, -22645, -18437, -16543, -3158, 1634, -13, 2587, -6316, 8963, 13895, 12709, 19492, 12594, -324, -6967, -15524, -11661, -12813, -6288, 256, -2118, 5361, 12436, 11899, 22667, 18552, 11696, 11776, 5528, 7875, 3055, 1329, -2381, -9992, -9345, 707, 4643, 816, -8353, -16952, -27140, -29766, -26924, -18797, -13402, -9147, -9701, -13702, -9919, -4097, -7690, -8447, -9108, -9439, -6635, 1955, 5533, 1007, -1216, -1019, -6270, 1100, 7402, 13805, 19150, 17082, 20160, 17335, 17637, 20338, 14591, 7988, 4111, -2759, -4740, -3264, -755, 1243, 4968, 218, 3033, -3941, -8433, -5669, -6936, -7782, -1174, 307, 2478, 8161, 4260, 4663, 1704, -2355, -964, -3101, 7797, 8679, 11076, 11448, 5163, 9152, -2607, -8001, -4056, -20355, -11069, -6925, -7153, 5176, -765, 10263, 12435, 11275, 18791, 11085, 7121, 11739, 2528, 1835, 6042, 7623, 7149, 3238, -227, -3449, -5601, -3955, -4928, -5481, -11885, -16962, -17117, -12565, -10715, -5246, -2008, -5569, -1345, -1676, 2038, 8188, 5770, 6103, -25, -5247, -4773, -10629, -3192, -6867, -4500, -2698, -746, -19, 6026, 7573, 4710, 4937, 3160, 2813, 10408, 9336, 4022, 2113, -278, 3728, 2103, 2385, -949, -4955, -5024, -5737, -3923, -1044, -7809, -387, -3277, -16125, -11212, -15923, -8524, -2585, -9209, 2459, -11294, -9312, -929, -8047, 9, 2186, 1563, 12469, 16762, 24515, 24518, 26464, 24039, 13924, 8696, 4439, 4165, 1880, -981, -13580, -13538, -18204, -12314, -3219, -3462, 4590, 6197, 8986, 15400, 12358, 12589, 1010, 3338, 4608, -1953, -5966, -13051, -22224, -21840, -17319, -11665, -2996, -2455};