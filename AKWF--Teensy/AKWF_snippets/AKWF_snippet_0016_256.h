/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_snippet_0016 256 samples */
 
const int16_t AKWF_snippet_0016_256_DATA [256] = 
{4573, 6652, 6469, 8730, 10513, 10543, 10117, 9817, 11048, 10105, 5106, 5318, 10658, 17839, 22301, 19636, 24117, 27920, 26391, 25652, 23184, 21998, 19760, 17889, 14372, 15591, 11622, 3829, -168, 1170, 5745, 9410, 9455, 10862, 15097, 19452, 17657, 14720, 17244, 16562, 12056, 6552, 5386, 10656, 13009, 7495, 1889, 178, 4042, 5425, 3166, 1419, 5815, 9653, 5649, 3608, 8665, 4823, 3526, 5701, 781, -1669, -2070, -5768, -9557, -9946, -11926, -15283, -12024, -9679, -6440, -408, -2538, -432, 5078, 11585, 8257, 2242, 3963, 4423, 5048, 4161, 105, 622, 7935, 8067, 2394, -420, 1291, 4488, 10084, 14398, 17217, 15251, 12893, 7979, 5351, 14062, 17933, 13140, 5243, 2712, -2730, -5057, -4198, 2845, 5901, 12409, 18298, 13640, 12406, 17399, 19658, 22236, 22476, 19628, 20196, 20707, 19921, 17449, 17366, 16466, 16409, 15251, 16764, 18459, 19784, 19491, 22252, 22892, 20790, 21335, 17607, 13183, 9794, 6480, 2402, 1484, -139, -4404, -12093, -14388, -18592, -19794, -15559, -9404, -8091, -8061, -9226, -10831, -11485, -9400, -14981, -15584, -9434, -15587, -17443, -18562, -26252, -28290, -26340, -26105, -29801, -31832, -23188, -17217, -17360, -18750, -12183, -12015, -14505, -13098, -12684, -10041, -8906, -9432, -14739, -14025, -18439, -19103, -15342, -2784, 1915, 3372, 4624, 8918, 9094, 11833, 10467, 12182, -6308, -16512, -12453, -6946, -11424, -6962, -3270, -728, -1717, 1229, -2369, -1761, -567, -8013, -15758, -11211, -17466, -20065, -22694, -28208, -28186, -23042, -23260, -19092, -13954, -17770, -18069, -15724, -16082, -12799, -11765, -13934, -18835, -15079, -18208, -16833, -10876, -9639, -10562, -12523, -14822, -13734, -12293, -7908, 500, 1901, -1868, 3488, 6077, -1040, -3435, -1207, -3407, -6927, -6549, -10738, -12864, -15248, -18483, -17407, -10042, -9185, -7272, -3153, 2121, -1832};