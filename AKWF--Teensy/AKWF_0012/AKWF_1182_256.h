/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1182 256 samples */
 
const int16_t AKWF_1182_256_DATA [256] = 
{24905, 24777, 27612, 29356, 30723, 31693, 32316, 32691, 32766, 32646, 32360, 31949, 31443, 30887, 30213, 29869, 30418, 29567, 28646, 27831, 27041, 26300, 25611, 24973, 24387, 23853, 23369, 22933, 22543, 22196, 21888, 21617, 21380, 21173, 20993, 20836, 20700, 20582, 20481, 20392, 20315, 20248, 20189, 20136, 20087, 20042, 20001, 19960, 19921, 19881, 19843, 19802, 19762, 19719, 19675, 19630, 19581, 19531, 19479, 19425, 19367, 19310, 19247, 19182, 19116, 19047, 18976, 18902, 18827, 18748, 18668, 18586, 18502, 18416, 18328, 18238, 18147, 18053, 17958, 17862, 17792, 17723, 17653, 17583, 17512, 17439, 17366, 17292, 17216, 17140, 17064, 16987, 16911, 16833, 16754, 16676, 16596, 16503, 16492, 15629, 14175, 12996, 11842, 10812, 9942, 9245, 8715, 8336, 8092, 7965, 7943, 8011, 8154, 8363, 8626, 8936, 9283, 9659, 10055, 10470, 10893, 11316, 11760, 12179, 12598, 12776, 14324, 9793, -20556, -22995, -24471, -25977, -26909, -27465, -27691, -27688, -27401, -26938, -26328, -25610, -24815, -23976, -23111, -22246, -21397, -20576, -19797, -19069, -18395, -17782, -17232, -16745, -16321, -15960, -15658, -15412, -15222, -15080, -14985, -14933, -14920, -14940, -14991, -15072, -15174, -15296, -15437, -15592, -15759, -15937, -16120, -16310, -16504, -16712, -16848, -17896, -19450, -20739, -21995, -23122, -24085, -24867, -25479, -25935, -26250, -26443, -26527, -26515, -26422, -26259, -26034, -25757, -25437, -25084, -24701, -24297, -23880, -23449, -23013, -22577, -22141, -21710, -21287, -20875, -20475, -20090, -19720, -19366, -19033, -18716, -18420, -18145, -17890, -17656, -17443, -17249, -17078, -16927, -16796, -16685, -16593, -16521, -16468, -16429, -16409, -16408, -16417, -16465, -16423, -16105, -15884, -15671, -15469, -15276, -15094, -14920, -14754, -14596, -14444, -14296, -14155, -14018, -13884, -13755, -13627, -13501, -13376, -13252, -13126, -12996, -12885, -12751, -12622, -12422, -12701, -10648};