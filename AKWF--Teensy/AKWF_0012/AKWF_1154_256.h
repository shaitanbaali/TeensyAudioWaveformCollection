/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1154 256 samples */
 
const int16_t AKWF_1154_256_DATA [256] = 
{611, 2268, 3699, 4974, 6104, 7104, 7989, 8767, 9452, 10054, 10580, 11039, 11437, 11781, 12077, 12330, 12543, 12721, 12868, 12988, 13082, 13153, 13203, 13237, 13254, 13256, 13244, 13221, 13188, 13145, 13093, 13034, 12967, 12894, 12816, 12733, 12645, 12553, 12457, 12358, 12256, 12151, 12044, 11933, 11821, 11708, 11592, 11474, 11356, 11236, 11114, 10991, 10867, 10742, 10616, 10490, 10362, 10234, 10106, 9975, 9845, 9714, 9583, 9450, 9317, 9184, 9050, 8916, 8781, 8645, 8509, 8374, 8236, 8099, 7961, 7823, 7684, 7545, 7406, 7265, 7125, 6984, 6842, 6701, 6559, 6415, 6273, 6129, 5985, 5841, 5696, 5551, 5406, 5260, 5114, 4966, 4819, 4671, 4523, 4375, 4226, 4077, 3927, 3776, 3626, 3474, 3323, 3171, 3019, 2866, 2712, 2559, 2405, 2250, 2095, 1940, 1785, 1627, 1471, 1314, 1156, 999, 840, 682, 522, 363, 203, 43, -117, -278, -438, -598, -758, -917, -1077, -1235, -1394, -1551, -1708, -1865, -2021, -2176, -2330, -2484, -2636, -2790, -2942, -3092, -3242, -3392, -3540, -3687, -3833, -3980, -4125, -4269, -4413, -4555, -4697, -4838, -4978, -5118, -5256, -5393, -5530, -5665, -5800, -5934, -6067, -6199, -6330, -6461, -6590, -6720, -6847, -6975, -7101, -7226, -7350, -7474, -7596, -7718, -7840, -7961, -8080, -8198, -8316, -8433, -8548, -8664, -8779, -8892, -9005, -9117, -9228, -9339, -9452, -9551, -9688, -10682, -11500, -11844, -11993, -11954, -11753, -11407, -10930, -10336, -9639, -8847, -7971, -7023, -6006, -4928, -3799, -2620, -1398, -141, 1154, 2479, 3795, 5287, 6182, 1261, -3293, -6399, -9237, -11781, -14067, -16131, -17999, -19683, -21210, -22596, -23849, -24990, -26028, -26970, -27834, -28624, -29345, -30008, -30619, -31180, -31691, -32117, -32877, -28557, -22069, -17958, -14273, -11016, -8121, -5536, -3239, -1163};