/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1160 256 samples */
 
const int16_t AKWF_1160_256_DATA [256] = 
{500, 1690, 2807, 3833, 4823, 5750, 6630, 7491, 8291, 9060, 9702, 10275, 10741, 11095, 11287, 11390, 11307, 11022, 10510, 9593, 8579, 8270, 8448, 8946, 9675, 10564, 11573, 12646, 13754, 14876, 15986, 17070, 18111, 19099, 20033, 20899, 21694, 22419, 23082, 23609, 24115, 24524, 24889, 25237, 25537, 25783, 25991, 26163, 26263, 26321, 26376, 26430, 26489, 26601, 26776, 27253, 31329, 31910, 29703, 28901, 28264, 27667, 27083, 27245, 12305, 4871, 10975, 11578, 11739, 11684, 11460, 11203, 10801, 10186, 9496, 8786, 8091, 7402, 6727, 6105, 5543, 5063, 4676, 4411, 4302, 4387, 4829, 5209, 11482, 17827, 13794, 12516, 12215, 12102, 12146, 12289, 12496, 12736, 12984, 13229, 13454, 13647, 13804, 13904, 13958, 13964, 13904, 13795, 13624, 13395, 13115, 12775, 12384, 11944, 11449, 10905, 10316, 9685, 9006, 8288, 7535, 6744, 5925, 5070, 4196, 3296, 2381, 1458, 525, -406, -1329, -2240, -3122, -3971, -4790, -5563, -6288, -6954, -7542, -8066, -8479, -8755, -8996, -9113, -9101, -8947, -8620, -8071, -7183, -6598, -6581, -6878, -7411, -8108, -8933, -9838, -10799, -11788, -12785, -13778, -14748, -15680, -16587, -17401, -18140, -18850, -19511, -20094, -20633, -21155, -21577, -22009, -22402, -22704, -22949, -23209, -23433, -23625, -23794, -23938, -24071, -24171, -24253, -24351, -24413, -25031, -23064, -13018, -9785, -10857, -11135, -11285, -11329, -11277, -11139, -10949, -10720, -10447, -10155, -9856, -9570, -9312, -9093, -8924, -8816, -8786, -8845, -8997, -9283, -9736, -10526, -11247, -16752, -24970, -21483, -19804, -19594, -19532, -19604, -19761, -19960, -20177, -20385, -20567, -20716, -20823, -20877, -20879, -20826, -20717, -20556, -20331, -20013, -19637, -19215, -18747, -18228, -17665, -17058, -16409, -15716, -14974, -14199, -13413, -12590, -11717, -10799, -9838, -8833, -7779, -6692, -5562, -4397, -3208, -1997, -745};