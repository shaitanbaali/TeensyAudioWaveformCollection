/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1115 256 samples */
 
const int16_t AKWF_1115_256_DATA [256] = 
{217, 2249, 4541, 6677, 9225, 14462, 17637, 18508, 16586, 15513, 21220, 20821, 20210, 19394, 19652, 18675, 17843, 20394, 22736, 22315, 21534, 20495, 18603, 17067, 15527, 16114, 17634, 19151, 3316, 134, 5615, 9510, 10798, 9671, 9243, 8216, 5659, 3039, 2453, 2543, 5685, 7178, 8454, 9719, 11538, 11840, 12457, 18652, 15954, 7927, 7280, 8647, 11648, 12761, 12158, 12467, 12787, 12993, 13806, 13761, 13630, 13512, 13301, 12523, 12259, 13760, 16445, 17676, 18787, 19273, 18993, 17858, 16455, 17277, 17838, 17179, 17331, 17581, 18158, 18713, 18897, 20369, 21497, 19915, 16157, 15161, 16576, 19650, 22910, 26064, 28040, 30746, 30428, 29549, 30821, 32580, 32630, 32580, 32644, 32529, 32165, 31040, 28768, 28814, 29469, 29123, 26701, 22454, 20184, 17106, 8955, 8414, 9342, 9824, 9252, 9364, 8945, 7975, 7390, 6424, 6305, 6167, 5117, 4399, 2620, 916, -609, -5215, -6257, -5125, -6325, -8875, -11663, -14683, -16996, -17772, -18529, -19271, -20780, -20964, -20424, -20463, -21275, -18587, -15926, -14302, -12225, -9842, -8552, -5913, -1833, -306, 697, -1100, -2123, -1243, 4872, 5807, 2939, -94, -2375, -4438, -7839, -8905, -8793, -7869, -9228, -11592, -16457, -18405, -19506, -21168, -21750, -22986, -24249, -26373, -26185, -22748, -21157, -20134, -20106, -19057, -17855, -18832, -18524, -15667, -15425, -14858, -15529, -15512, -15933, -15442, -15047, -14223, -12511, -12678, -13110, -15063, -15835, -16778, -17518, -17537, -16276, -17338, -18402, -16770, -15491, -13379, -12397, -12216, -11487, -10167, -10872, -11635, -12155, -13793, -15323, -16354, -15933, -16202, -15711, -15336, -16892, -21009, -22969, -26710, -29296, -29833, -31641, -30713, -26299, -25688, -26927, -27848, -27727, -26509, -25764, -23563, -21552, -22352, -23192, -22638, -22203, -23044, -21815, -20546, -17632, -13932, -14839, -15207, -12427, -9339, -6477, -2654, -978, -270};