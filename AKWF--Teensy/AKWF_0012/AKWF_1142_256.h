/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1142 256 samples */
 
const int16_t AKWF_1142_256_DATA [256] = 
{443, 1105, 1871, 2553, 3154, 3731, 4283, 4816, 5331, 5830, 6313, 6778, 7235, 7677, 8107, 8525, 8930, 9323, 9707, 10078, 10440, 10792, 11131, 11462, 11783, 12094, 12396, 12689, 12971, 13246, 13512, 13769, 14019, 14258, 14490, 14715, 14932, 15141, 15341, 15534, 15721, 15900, 16072, 16238, 16397, 16548, 16693, 16833, 16964, 17090, 17212, 17325, 17433, 17536, 17632, 17723, 17826, 17811, 18502, 19523, 19935, 20319, 20637, 20911, 21156, 21372, 21564, 21737, 21890, 22023, 22139, 22238, 22321, 22388, 22439, 22474, 22495, 22501, 22492, 22469, 22431, 22379, 22314, 22234, 22141, 22034, 21912, 21778, 21630, 21470, 21295, 21108, 20908, 20696, 20470, 20233, 19982, 19721, 19447, 19159, 18861, 18548, 18225, 17909, 16491, 15435, 14783, 14171, 13620, 13105, 12615, 12146, 11695, 11258, 10834, 10418, 10011, 9612, 9221, 8836, 8457, 8082, 7712, 7346, 6984, 6626, 6270, 5918, 5567, 5217, 4872, 4528, 4184, 3841, 3499, 3158, 2818, 2470, 2154, 1720, 328, -479, -901, -1435, -1971, -2495, -3066, -3373, -3306, -3542, -3787, -4046, -4309, -4573, -4837, -5097, -5356, -5613, -5868, -6122, -6375, -6627, -6878, -7129, -7382, -7636, -7900, -8123, -8506, -10575, -11829, -12684, -13446, -14103, -14680, -15187, -15621, -15989, -16273, -16534, -18308, -19441, -21362, -23023, -24069, -25023, -25876, -26648, -27355, -28008, -28607, -29159, -29671, -30137, -30564, -30952, -31298, -31609, -31883, -32117, -32316, -32478, -32605, -32695, -32749, -32768, -32752, -32701, -32615, -32495, -32340, -32153, -31932, -31632, -31567, -30353, -23952, -22483, -22755, -22417, -22070, -21729, -21237, -21461, -22342, -22333, -22228, -22011, -21720, -21364, -20954, -20497, -19997, -19459, -18884, -18274, -17619, -17001, -15981, -14731, -13832, -12939, -12064, -11234, -10270, -8473, -7251, -6254, -5339, -4492, -3699, -2944, -2225, -1532, -865, -193};