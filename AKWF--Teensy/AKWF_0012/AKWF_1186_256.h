/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1186 256 samples */
 
const int16_t AKWF_1186_256_DATA [256] = 
{30426, 30175, 29929, 29683, 29437, 29188, 28940, 28694, 28447, 28200, 27954, 27708, 27458, 27212, 26965, 26718, 26472, 26225, 25978, 25731, 25482, 25235, 24989, 24742, 24495, 24249, 24002, 23753, 23506, 23260, 23013, 22766, 22519, 22273, 22024, 21777, 21530, 21284, 21037, 20790, 20544, 20295, 20048, 19801, 19554, 19308, 19061, 18814, 18567, 18319, 18072, 17826, 17579, 17332, 17086, 16838, 16589, 16343, 16096, 15849, 15603, 15356, 15110, 14861, 14613, 14367, 14120, 13873, 13627, 13380, 13132, 12884, 12638, 12391, 12144, 11897, 11651, 11403, 11155, 10908, 10662, 10415, 10168, 9922, 9675, 9426, 9179, 8932, 8686, 8439, 8192, 7946, 7697, 7450, 7203, 6957, 6710, 6463, 6217, 5968, 5721, 5474, 5227, 4981, 4734, 4487, 4240, 3991, 3745, 3498, 3252, 3005, 2759, 2511, 2262, 2016, 1769, 1522, 1276, 1029, 782, 534, 286, 40, -206, -453, -699, -945, -1194, -1442, -1688, -1935, -2181, -2428, -2675, -2923, -3171, -3418, -3664, -3911, -4158, -4404, -4651, -4900, -5146, -5393, -5640, -5886, -6133, -6380, -6628, -6876, -7122, -7369, -7616, -7863, -8109, -8358, -8605, -8852, -9098, -9345, -9591, -9838, -10085, -10334, -10581, -10827, -11074, -11321, -11567, -11814, -12063, -12310, -12556, -12804, -13049, -13297, -13543, -13792, -14039, -14286, -14532, -14779, -15026, -15272, -15520, -15769, -16015, -16262, -16508, -16755, -17001, -17249, -17497, -17744, -17990, -18237, -18484, -18730, -18977, -19227, -19473, -19720, -19967, -20213, -20460, -20707, -20955, -21203, -21449, -21695, -21942, -22189, -22435, -22684, -22932, -23178, -23425, -23672, -23918, -24165, -24412, -24661, -24907, -25154, -25400, -25647, -25894, -26141, -26390, -26636, -26883, -27130, -27376, -27623, -27870, -28118, -28366, -28610, -28837, -29027, -29133, -29251, -29365, -29480, -29595, -29711, -29825, -29939, -30056, -30171, -30285, -30436, -30356, -31525};