/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1105 256 samples */
 
const int16_t AKWF_1105_256_DATA [256] = 
{247, 688, 1198, 1794, 2485, 3273, 4160, 5137, 6205, 7350, 8553, 9809, 11097, 12397, 13706, 15014, 16312, 17607, 18888, 20153, 21408, 22641, 23844, 25010, 26120, 27159, 28121, 28993, 29774, 30455, 31022, 31474, 31800, 31983, 32010, 31827, 31407, 31064, 30803, 30573, 30377, 30216, 30093, 30004, 29952, 29939, 29963, 30021, 30108, 30208, 30313, 30398, 30451, 30457, 30406, 30292, 30101, 29828, 29465, 29011, 28467, 27836, 27128, 26352, 25517, 24637, 23716, 22763, 21792, 20809, 19826, 18863, 17925, 17023, 16165, 15356, 14600, 13901, 13263, 12690, 12190, 11764, 11417, 11146, 10952, 10825, 10759, 10733, 10734, 10742, 10740, 10711, 10643, 10526, 10353, 10117, 9810, 9432, 8978, 8452, 7863, 7221, 6544, 5854, 5169, 4512, 3903, 3357, 2880, 2483, 2165, 1915, 1722, 1568, 1431, 1293, 1135, 941, 696, 388, 9, -452, -990, -1611, -2307, -3069, -3889, -4763, -5690, -6660, -7668, -8721, -9807, -10925, -12070, -13232, -14405, -15582, -16752, -17927, -19099, -20259, -21404, -22532, -23627, -24685, -25696, -26647, -27537, -28358, -29105, -29786, -30403, -30954, -31440, -31856, -32200, -32458, -32606, -32589, -32571, -32618, -32673, -32724, -32759, -32767, -32738, -32656, -32508, -32289, -31994, -31623, -31174, -30655, -30066, -29410, -28698, -27935, -27138, -26317, -25478, -24631, -23787, -22940, -22095, -21253, -20409, -19564, -18719, -17864, -17008, -16147, -15284, -14428, -13584, -12754, -11952, -11176, -10428, -9714, -9027, -8366, -7746, -7173, -6657, -6206, -5820, -5504, -5267, -5102, -5008, -4980, -5010, -5091, -5219, -5390, -5597, -5829, -6073, -6330, -6578, -6808, -7014, -7185, -7335, -7646, -8062, -8481, -8917, -9370, -9814, -10214, -10533, -10733, -10787, -10669, -10386, -9944, -9366, -8680, -7923, -7127, -6327, -5552, -4811, -4126, -3501, -2935, -2439, -2011, -1641, -1319, -1025, -740, -445, -113};