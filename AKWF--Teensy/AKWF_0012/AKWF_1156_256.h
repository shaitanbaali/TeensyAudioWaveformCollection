/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1156 256 samples */
 
const int16_t AKWF_1156_256_DATA [256] = 
{572, 2499, 4527, 6660, 8846, 11049, 13252, 15430, 17570, 19642, 21605, 23447, 25151, 26702, 28098, 29320, 30356, 31207, 31871, 32349, 32647, 32767, 32712, 32490, 32113, 31588, 30923, 30128, 29211, 28180, 27049, 25822, 24504, 23110, 21644, 20109, 18521, 16881, 15197, 13482, 11738, 9977, 8214, 6453, 4706, 2993, 1318, -303, -1850, -3316, -4685, -5938, -7069, -8059, -8895, -9571, -10075, -10398, -10537, -10487, -10245, -9812, -9192, -8391, -7411, -6268, -4970, -3527, -1959, -279, 1497, 3347, 5260, 7215, 9186, 11166, 13133, 15066, 16956, 18784, 20530, 22194, 23756, 25202, 26530, 27729, 28788, 29707, 30477, 31093, 31556, 31858, 32000, 31980, 31799, 31454, 30947, 30280, 29454, 28470, 27337, 26053, 24623, 23060, 21361, 19537, 17604, 15560, 13420, 11203, 8911, 6560, 4172, 1750, -684, -3110, -5524, -7902, -10224, -12488, -14665, -16745, -18720, -20570, -22284, -23859, -25278, -26536, -27630, -28552, -29299, -29872, -30271, -30495, -30549, -30437, -30163, -29737, -29162, -28450, -27607, -26646, -25574, -24403, -23145, -21809, -20406, -18953, -17451, -15920, -14370, -12807, -11247, -9701, -8173, -6682, -5233, -3834, -2498, -1234, -46, 1052, 2055, 2961, 3756, 4437, 5003, 5446, 5763, 5956, 6019, 5954, 5763, 5447, 5008, 4451, 3785, 3008, 2133, 1168, 120, -1001, -2184, -3422, -4701, -6009, -7338, -8673, -10004, -11324, -12615, -13871, -15084, -16240, -17333, -18357, -19302, -20163, -20936, -21612, -22193, -22675, -23053, -23328, -23501, -23572, -23541, -23411, -23186, -22868, -22461, -21972, -21404, -20762, -20058, -19291, -18474, -17612, -16713, -15786, -14840, -13881, -12921, -11968, -11027, -10113, -9232, -8392, -7604, -6873, -6207, -5616, -5106, -4682, -4352, -4117, -3984, -3958, -4039, -4229, -4529, -4941, -5462, -6087, -6826, -7564, -8032, -8176, -8053, -7739, -7234, -6497, -5494, -4237, -2785, -1137};