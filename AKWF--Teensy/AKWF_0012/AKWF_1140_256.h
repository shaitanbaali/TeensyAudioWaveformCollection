/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1140 256 samples */
 
const int16_t AKWF_1140_256_DATA [256] = 
{219, 746, 1265, 1786, 2303, 2821, 3320, 3791, 4209, 4801, 5343, 5742, 6136, 6499, 6836, 7142, 7420, 7672, 7897, 8092, 8261, 8402, 8515, 8602, 8663, 8696, 8703, 8683, 8638, 8569, 8474, 8354, 8212, 8045, 7854, 7643, 7411, 7149, 7426, 7961, 8470, 8999, 9537, 10092, 10656, 11229, 11813, 12403, 13000, 13606, 14218, 14831, 15451, 16069, 16691, 17315, 17938, 18560, 19177, 19791, 20403, 21009, 21609, 22202, 22777, 23372, 23823, 23861, 23871, 23871, 23858, 23832, 23793, 23741, 23676, 23598, 23507, 23404, 23288, 23158, 23018, 22866, 22699, 22521, 22331, 22128, 21916, 21690, 21453, 21204, 20944, 20674, 20392, 20098, 19795, 19482, 19159, 18825, 18481, 18127, 17764, 17393, 17013, 16622, 16224, 15817, 15403, 14982, 14551, 14115, 13671, 13220, 12764, 12301, 11831, 11357, 10876, 10389, 9903, 9407, 8909, 8407, 7900, 7391, 6882, 6365, 5848, 5329, 4807, 4287, 3765, 3240, 2720, 2187, 1626, 1046, 403, -20, -483, -1119, -1743, -2392, -3066, -3733, -4576, -4509, -4163, -4848, -5204, -5482, -5580, -6739, -7749, -7799, -7986, -8115, -8212, -8279, -8317, -8323, -8299, -8248, -8224, -7793, -11486, -13633, -14093, -14974, -15539, -14552, -15197, -15938, -16651, -17371, -18081, -18881, -19361, -15205, -16138, -17920, -19523, -21169, -22856, -24403, -25208, -25857, -26528, -27182, -27820, -28443, -29054, -29651, -30233, -30793, -31338, -31855, -32400, -32665, -32166, -31633, -31084, -30513, -29926, -29320, -28702, -28069, -27421, -26760, -26088, -25405, -24715, -24014, -23305, -22589, -21868, -21144, -20417, -19684, -18950, -18215, -17480, -16750, -16019, -15290, -14568, -13834, -13335, -13004, -12638, -12267, -11888, -11500, -11106, -10701, -10290, -9869, -9441, -9008, -8569, -8120, -7667, -7206, -6739, -6270, -5794, -5311, -4825, -4336, -3841, -3342, -2839, -2333, -1825, -1317, -805, -280};