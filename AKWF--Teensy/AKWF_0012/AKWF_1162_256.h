/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1162 256 samples */
 
const int16_t AKWF_1162_256_DATA [256] = 
{201, 787, 445, 6330, 17742, 19972, 19739, 20110, 20335, 20473, 20460, 20346, 20240, 20191, 20192, 20191, 20198, 20215, 20248, 20297, 20362, 20446, 20548, 20669, 20808, 20963, 21136, 21326, 21529, 21748, 21982, 22229, 22487, 22755, 23034, 23321, 23614, 23912, 24217, 24528, 24845, 25166, 25491, 25821, 26155, 26492, 26833, 27177, 27523, 27870, 28220, 28559, 28883, 29207, 29529, 29849, 30167, 30483, 30799, 31112, 31424, 31736, 32044, 32347, 32599, 32673, 31902, 30966, 30041, 29101, 28161, 27234, 26315, 25421, 24624, 23863, 23116, 22388, 21679, 20988, 20315, 19671, 19055, 18460, 17895, 17348, 16820, 16307, 15809, 15322, 14850, 14389, 13939, 13496, 13063, 12640, 12220, 11808, 11403, 11002, 10606, 10215, 9827, 9445, 9064, 8687, 8312, 7938, 7568, 7201, 6832, 6467, 6104, 5742, 5378, 5019, 4660, 4301, 3943, 3585, 3231, 2881, 2530, 2179, 1832, 1482, 1133, 786, 396, 100, -194, -14371, -19387, -18638, -19074, -19266, -19373, -19391, -19258, -19094, -18976, -18923, -18868, -18821, -18781, -18754, -18742, -18746, -18768, -18807, -18864, -18937, -19027, -19137, -19258, -19397, -19549, -19715, -19894, -20084, -20285, -20495, -20716, -20946, -21183, -21426, -21674, -21922, -22177, -22436, -22699, -22965, -23234, -23506, -23780, -24057, -24336, -24618, -24900, -25183, -25467, -25754, -26041, -26327, -26615, -26905, -27194, -27481, -27748, -28008, -28267, -28523, -28775, -29026, -29274, -29520, -29764, -30006, -30248, -30486, -30723, -30958, -31178, -31469, -31303, -30349, -29312, -28295, -27355, -26411, -25480, -24569, -23673, -22802, -21956, -21130, -20330, -19558, -18827, -18121, -17441, -16780, -16139, -15518, -14913, -14325, -13753, -13193, -12647, -12112, -11586, -11072, -10569, -10070, -9580, -9098, -8621, -8151, -7684, -7222, -6766, -6312, -5859, -5413, -4969, -4527, -4087, -3650, -3215, -2781, -2349, -1918, -1494, -1071, -650, -222};