/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1174 256 samples */
 
const int16_t AKWF_1174_256_DATA [256] = 
{1467, 3764, 5424, 8077, 11346, 13956, 16363, 19151, 21466, 23246, 24692, 25803, 26403, 27056, 28021, 28612, 28986, 30019, 30974, 31557, 31944, 32203, 32115, 32003, 32427, 32699, 32736, 32724, 32619, 32329, 31861, 31280, 30574, 29799, 28965, 28084, 27196, 26287, 25390, 24505, 23643, 22818, 22018, 21269, 20552, 19883, 19280, 18629, 17837, 17085, 16417, 16041, 15810, 15620, 15454, 15328, 15185, 15180, 15953, 16849, 17662, 18347, 18936, 19429, 19828, 20166, 20416, 20622, 20772, 20852, 20991, 20674, 19718, 18779, 17936, 17212, 16568, 16061, 15461, 14789, 14266, 13630, 12361, 11106, 10054, 9000, 7995, 7259, 6338, 4917, 3657, 2621, 1617, 715, 147, -874, -2449, -3727, -4879, -6512, -7995, -9153, -10177, -11056, -11667, -12043, -12214, -12200, -12039, -12470, -13068, -13457, -13772, -14105, -14273, -14262, -13905, -13369, -12863, -11726, -10105, -8572, -7151, -5865, -4704, -3669, -2551, -1445, -471, 376, 1109, 1713, 2271, 3487, 4800, 5932, 6860, 7619, 8209, 8658, 8986, 9193, 9313, 9344, 9304, 9213, 9058, 8876, 8659, 8406, 7405, 6151, 5009, 3985, 3080, 2301, 1582, 755, -40, -644, -1760, -3213, -4450, -5576, -6702, -7661, -8415, -9898, -11621, -12980, -14469, -16328, -17888, -19160, -20340, -21317, -21953, -22905, -24148, -25112, -25808, -26260, -26483, -26532, -26416, -26171, -25818, -25373, -24866, -24296, -23703, -23300, -22936, -22541, -22108, -21652, -21178, -20702, -20217, -19753, -19239, -19376, -19937, -20391, -20832, -21381, -21825, -22176, -23143, -24275, -25230, -25978, -26573, -26992, -27312, -27739, -28094, -28342, -28472, -28533, -28450, -28535, -29304, -30029, -30628, -31054, -31346, -31530, -31590, -31587, -31491, -31341, -31148, -30898, -30645, -30345, -30034, -29763, -29291, -28100, -26827, -25710, -24531, -23352, -22434, -21206, -19272, -17483, -15928, -13704, -11382, -9551, -7431, -4904, -2823, -909};