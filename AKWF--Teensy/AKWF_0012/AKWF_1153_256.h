/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1153 256 samples */
 
const int16_t AKWF_1153_256_DATA [256] = 
{131, 402, 667, 933, 1198, 1464, 1731, 1997, 2263, 2529, 2793, 3060, 3325, 3591, 3857, 4123, 4388, 4654, 4920, 5184, 5450, 5716, 5981, 6247, 6513, 6777, 7043, 7308, 7573, 7839, 8104, 8369, 8635, 8900, 9165, 9431, 9696, 9961, 10226, 10491, 10757, 11022, 11287, 11552, 11818, 12083, 12348, 12613, 12878, 13143, 13409, 13674, 13939, 14204, 14469, 14735, 15000, 15264, 15530, 15795, 16060, 16326, 16591, 16856, 17121, 17386, 17651, 17917, 18181, 18447, 18712, 18976, 19242, 19508, 19772, 20038, 20303, 20567, 20833, 21098, 21363, 21628, 21894, 22158, 22424, 22689, 22953, 23219, 23484, 23749, 24015, 24279, 24544, 24810, 25075, 25340, 25605, 25870, 26135, 26401, 26666, 26931, 27196, 27460, 27726, 27991, 28256, 28521, 28786, 29052, 29316, 29582, 29847, 30112, 30377, 30642, 30907, 31173, 31437, 31703, 31968, 32206, 32526, 32548, 26953, 19549, 13089, 7022, 1484, -3472, -7872, -11751, -15131, -18067, -20606, -22777, -24630, -26199, -27512, -28603, -29497, -30217, -30786, -31220, -31536, -31751, -31877, -31924, -31903, -31824, -31695, -31523, -31312, -31071, -30802, -30511, -30200, -29874, -29534, -29184, -28826, -28462, -28092, -27718, -27343, -26966, -26588, -26212, -25836, -25460, -25088, -24717, -24348, -23984, -23621, -23262, -22906, -22552, -22201, -21855, -21511, -21170, -20834, -20499, -20168, -19840, -19514, -19192, -18872, -18554, -18240, -17927, -17616, -17308, -17002, -16698, -16396, -16097, -15798, -15502, -15207, -14914, -14622, -14332, -14042, -13755, -13468, -13182, -12898, -12615, -12332, -12051, -11770, -11491, -11212, -10934, -10656, -10379, -10103, -9828, -9553, -9278, -9004, -8732, -8458, -8186, -7914, -7642, -7370, -7100, -6829, -6559, -6289, -6019, -5750, -5480, -5211, -4943, -4674, -4405, -4137, -3869, -3601, -3333, -3066, -2798, -2532, -2264, -1997, -1731, -1463, -1197, -930, -664, -398, -128};