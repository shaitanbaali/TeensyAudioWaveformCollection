/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1170 256 samples */
 
const int16_t AKWF_1170_256_DATA [256] = 
{32765, 32767, 32768, 32767, 32766, 32760, 32755, 32749, 32741, 32244, 34835, 21602, -16756, -16191, -16155, -16246, -16247, -16249, -16248, -16247, -16099, -16720, -14692, 28582, 33785, 32442, 32695, 32691, 32685, 32679, 32671, 32662, 32280, 34224, 25016, -15616, -16591, -16193, -16327, -16329, -16331, -16331, -16330, -15623, -19452, -1699, 35397, 31999, 32587, 32609, 32604, 32598, 32590, 32583, 32575, 32567, 32558, 32548, 32537, 32526, 32516, 32505, 32494, 32482, 32472, 32460, 32448, 32435, 32425, 32412, 32401, 32389, 32377, 32364, 32352, 32341, 32242, 32119, 33377, -4609, -19189, -16073, -16664, -16668, -16671, -16674, -16673, -16673, -16674, -16673, -16669, -16668, -16665, -16662, -16659, -16654, -16651, -16647, -16642, -16637, -16634, -16628, -16624, -16618, -16614, -16609, -16604, -16599, -16594, -16589, -16583, -16578, -16573, -16568, -16563, -16558, -16553, -16548, -16542, -16537, -16532, -16527, -16522, -16517, -16511, -16507, -16502, -16497, -16493, -16487, -16482, -16478, -16473, -16469, -16464, -16459, -16455, -16450, -16445, -16440, -16437, -16432, -16427, -16423, -16419, -16414, -16410, -16405, -16401, -16397, -16392, -16388, -16384, -16381, -16377, -16372, -16368, -16365, -16361, -16357, -16353, -16349, -16345, -16341, -16338, -16335, -16331, -16328, -16323, -16320, -16317, -16313, -16310, -16306, -16304, -16300, -16297, -16293, -16290, -16287, -16283, -16282, -16278, -16275, -16272, -16270, -16266, -16264, -16261, -16258, -16255, -16254, -16251, -16247, -16246, -16242, -16240, -16238, -16236, -16232, -16231, -16229, -16225, -16224, -16223, -16220, -16217, -16215, -16213, -16211, -16209, -16207, -16207, -16205, -16202, -16200, -16199, -16199, -16197, -16195, -16192, -16191, -16190, -16189, -16187, -16186, -16185, -16183, -16183, -16182, -16180, -16179, -16179, -16178, -16176, -16176, -16174, -16173, -16173, -16171, -16171, -16171, -16172, -16171, -16171, -16168, -16181, -16475, -16944, -17274, -17364, -17223, -16928, -16590, -16312, -16177};