/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1183 256 samples */
 
const int16_t AKWF_1183_256_DATA [256] = 
{384, 1462, 2342, 2970, 3410, 3722, 3943, 4101, 4214, 4295, 4351, 4391, 4416, 4432, 4441, 4447, 4451, 4457, 4467, 4483, 4508, 4542, 4588, 4646, 4717, 4802, 4900, 5010, 5130, 5259, 5396, 5538, 5680, 5821, 5958, 6088, 6208, 6316, 6411, 6488, 6548, 6591, 6617, 6625, 6618, 6598, 6566, 6527, 6482, 6437, 6391, 6352, 6323, 6307, 6306, 6320, 6353, 6405, 6479, 6575, 6688, 6815, 6951, 7098, 7257, 7421, 7578, 7721, 7848, 7965, 8072, 8162, 8212, 8224, 8201, 8170, 8127, 8064, 7948, 7787, 7615, 7471, 7361, 7225, 7042, 6803, 6635, 6540, 6552, 6464, 6307, 6049, 5974, 6037, 6183, 6074, 5664, 5204, 4919, 5009, 4693, 3888, 2152, 1140, 579, 1349, 1185, 578, -1339, -1845, -1003, 358, 3936, -15212, -25426, -20294, -22409, -23728, -24684, -25053, -24999, -24768, -24490, -24232, -24029, -23883, -23771, -23667, -23569, -23430, -23134, -22611, -21939, -21181, -20402, -19505, -19194, -20265, -21374, -22643, -24029, -25505, -26585, -30766, -19388, -2714, -4857, -2823, -1948, -1243, -755, -450, -304, -291, -389, -576, -833, -1146, -1495, -1872, -2263, -2661, -3058, -3446, -3821, -4180, -4521, -4841, -5137, -5411, -5661, -5889, -6092, -6274, -6433, -6572, -6690, -6788, -6868, -6930, -6978, -7009, -7026, -7031, -7024, -7007, -6981, -6948, -6908, -6864, -6816, -6767, -6716, -6665, -6616, -6568, -6522, -6479, -6440, -6404, -6371, -6339, -6309, -6282, -6253, -6224, -6191, -6155, -6113, -6063, -6004, -5935, -5854, -5759, -5648, -5521, -5375, -5208, -5018, -4802, -4560, -4285, -3972, -3616, -3206, -2733, -2177, -1516, -695, 334, 1443, 2390, 3131, 3688, 4087, 4360, 4532, 4624, 4643, 4530, 4606, 1220, -6619, -9057, -8658, -7785, -6981, -6472, -6136, -5768, -5270, -4614, -3796, -2840, -1797, -693};