/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1196 256 samples */
 
const int16_t AKWF_1196_256_DATA [256] = 
{3223, 3847, 4454, 5030, 5568, 6111, 6690, 7289, 7836, 8289, 8662, 9006, 9344, 9642, 9900, 10195, 10508, 10819, 11196, 11578, 11999, 12540, 13125, 13674, 14125, 14481, 14837, 15158, 15421, 15701, 16008, 16286, 16477, 16595, 16658, 16691, 16728, 16776, 16791, 16781, 16766, 16747, 16720, 16681, 16631, 16569, 16523, 16447, 16338, 16211, 16089, 16018, 15981, 15965, 15996, 16050, 16127, 16235, 16372, 16550, 16739, 16976, 16829, 18089, 29853, 30768, 30584, 30691, 30773, 30925, 31137, 31377, 31626, 31868, 32092, 32298, 32458, 32585, 32673, 32743, 32768, 32731, 32662, 32572, 32423, 32240, 32046, 31814, 31562, 31335, 31107, 30844, 30578, 30327, 30077, 29724, 28847, 27927, 27070, 26348, 25727, 25177, 24620, 24035, 23441, 22811, 22201, 21644, 21127, 20642, 20195, 19763, 19299, 18800, 18352, 17984, 17647, 17280, 16857, 16362, 15855, 15406, 15017, 14675, 14370, 13979, 14064, 12206, -4783, -6367, -6232, -6508, -6703, -6927, -7188, -7429, -7643, -7823, -7941, -8036, -8183, -8383, -8563, -8715, -8839, -8967, -9121, -9294, -9470, -9648, -9806, -9921, -9993, -10041, -10160, -10339, -10515, -10706, -10866, -10953, -10988, -11024, -11093, -11168, -11238, -11324, -11434, -11539, -11667, -11767, -11750, -11683, -11628, -11616, -11652, -11757, -11934, -12145, -12361, -12565, -12733, -12887, -13062, -13294, -13596, -13893, -14183, -14448, -14824, -14093, -18673, -29181, -28642, -28894, -29004, -29113, -29235, -29401, -29504, -29446, -29319, -29194, -29103, -29038, -28997, -29005, -29059, -29098, -29064, -28989, -28893, -28693, -28381, -28005, -27612, -27185, -26768, -26392, -26024, -25673, -25381, -25132, -24890, -24697, -24591, -24546, -24539, -24576, -24596, -24595, -24537, -24419, -24198, -23879, -23505, -23087, -22625, -22143, -21695, -21286, -20905, -20556, -20258, -20026, -19799, -19535, -19221, -18897, -18637, -18385, -18148, -17882, -17535, -17176, -16808, -16109};