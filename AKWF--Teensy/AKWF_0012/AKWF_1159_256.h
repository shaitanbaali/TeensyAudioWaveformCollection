/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1159 256 samples */
 
const int16_t AKWF_1159_256_DATA [256] = 
{2619, 6628, 10520, 14299, 17866, 21148, 24069, 26544, 28522, 29949, 30786, 31009, 30608, 29584, 27949, 25735, 22996, 19771, 16137, 12176, 7952, 3567, -879, -5316, -9634, -13742, -17573, -21033, -24057, -26593, -28584, -29999, -30818, -31026, -30629, -29641, -28095, -26024, -23478, -20525, -17215, -13623, -9838, -5918, -1945, 1988, 5831, 9503, 12930, 16071, 18868, 21270, 23258, 24799, 25876, 26486, 26629, 26317, 25566, 24405, 22865, 20979, 18791, 16446, 14358, 12838, 11874, 11372, 11286, 11618, 12359, 13420, 14653, 15892, 17003, 17906, 18525, 18770, 18551, 17795, 16484, 14622, 12243, 9390, 6096, 2443, -1468, -5543, -9653, -13685, -17543, -21103, -24258, -26919, -28992, -30418, -31151, -31160, -30433, -28975, -26820, -24014, -20619, -16730, -12422, -7799, -2992, 1906, 6771, 11475, 15930, 20024, 23654, 26759, 29264, 31115, 32290, 32764, 32540, 31635, 30083, 27934, 25237, 22074, 18524, 14661, 10587, 6390, 2149, -2028, -6072, -9910, -13458, -16669, -19495, -21886, -23825, -25294, -26281, -26796, -26850, -26466, -25671, -24499, -22995, -21193, -19142, -16896, -14488, -11972, -9395, -6788, -4198, -1665, 791, 3131, 5330, 7374, 9233, 10896, 12351, 13584, 14588, 15357, 15883, 16168, 16209, 16008, 15568, 14894, 13995, 12880, 11561, 10061, 8387, 6566, 4628, 2591, 489, -1639, -3773, -5867, -7883, -9794, -11555, -13132, -14499, -15619, -16469, -17028, -17278, -17210, -16820, -16110, -15089, -13771, -12184, -10350, -8305, -6095, -3754, -1332, 1112, 3540, 5898, 8128, 10195, 12047, 13642, 14952, 15946, 16601, 16904, 16848, 16435, 15673, 14579, 13177, 11492, 9567, 7439, 5148, 2751, 292, -2147, -4435, -6598, -8678, -10633, -12410, -13962, -15256, -16316, -17164, -17829, -18505, -19286, -20135, -20991, -21825, -22612, -23334, -23930, -24326, -24445, -24237, -23673, -22726, -21377, -19605, -17402, -14797, -11829, -8542, -4999, -1170};