/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1129 256 samples */
 
const int16_t AKWF_1129_256_DATA [256] = 
{5988, 5954, 5948, 5954, 5959, 5962, 5965, 5969, 5973, 5976, 5979, 5981, 5985, 5988, 5990, 5993, 5996, 5998, 6001, 6003, 6005, 6008, 6011, 6012, 6015, 6017, 6019, 6021, 6024, 6026, 6028, 6030, 6032, 6034, 6037, 6038, 6040, 6043, 6045, 6047, 6048, 6051, 6053, 6055, 6057, 6058, 6061, 6063, 6064, 6067, 6069, 6070, 6073, 6075, 6076, 6079, 6081, 6082, 6084, 6086, 6088, 6212, 5607, 7888, 31135, 32858, 32390, 32487, 32485, 32481, 32477, 32471, 32465, 32458, 32452, 32444, 32436, 32428, 32419, 32410, 32401, 32391, 32382, 32372, 32361, 32351, 32341, 32329, 32319, 32308, 32297, 32286, 32275, 32263, 32251, 32240, 32229, 32218, 32206, 32194, 32182, 32170, 32159, 32147, 32135, 32123, 32112, 32099, 32087, 32075, 32064, 32052, 32039, 32027, 32016, 32004, 31991, 31980, 31968, 31955, 31944, 31932, 31920, 31908, 31896, 31718, 32522, 29472, -3687, -6271, -5545, -5702, -5707, -5711, -5714, -5717, -5721, -5724, -5728, -5731, -5733, -5736, -5740, -5743, -5745, -5748, -5751, -5753, -5755, -5758, -5760, -5763, -5765, -5767, -5769, -5772, -5773, -5776, -5778, -5780, -5783, -5785, -5787, -5789, -5791, -5793, -5796, -5798, -5800, -5802, -5804, -5806, -5808, -5810, -5813, -5814, -5816, -5819, -5820, -5822, -5825, -5827, -5828, -5831, -5833, -5834, -5837, -5837, -6173, -4340, -13036, -33459, -31973, -32226, -32236, -32233, -32230, -32225, -32219, -32213, -32206, -32200, -32193, -32184, -32176, -32168, -32158, -32149, -32139, -32130, -32119, -32109, -32099, -32089, -32079, -32067, -32056, -32045, -32034, -32023, -32012, -32001, -31989, -31977, -31966, -31954, -31942, -31931, -31920, -31908, -31896, -31884, -31873, -31860, -31848, -31837, -31825, -31813, -31801, -31789, -31777, -31766, -31753, -31742, -31730, -31717, -31706, -31694, -31682, -31670, -31658, -31647, -31634, -31606, -31677, -31322};