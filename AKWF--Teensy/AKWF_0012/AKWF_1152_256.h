/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1152 256 samples */
 
const int16_t AKWF_1152_256_DATA [256] = 
{111, 419, 724, 1029, 1333, 1640, 1946, 2254, 2561, 2870, 3178, 3488, 3798, 4107, 4418, 4729, 5040, 5352, 5664, 5976, 6289, 6603, 6915, 7230, 7544, 7858, 8173, 8488, 8804, 9120, 9436, 9751, 10068, 10385, 10702, 11020, 11336, 11654, 11973, 12290, 12609, 12928, 13246, 13565, 13885, 14203, 14523, 14843, 15162, 15482, 15802, 16123, 16444, 16764, 17084, 17406, 17726, 18047, 18369, 18691, 19012, 19334, 19656, 19977, 20299, 20621, 20944, 21266, 21588, 21911, 22234, 22556, 22878, 23202, 23525, 23848, 24171, 24493, 24816, 25141, 25464, 25787, 26111, 26434, 26758, 27082, 27405, 27729, 28053, 28377, 28702, 29025, 29349, 29673, 29998, 30322, 30645, 30971, 31295, 31619, 31943, 32200, 32902, 24054, 20178, 17494, 15039, 12878, 10929, 9139, 7467, 5894, 4412, 3004, 1666, 396, -814, -1967, -3064, -4110, -5106, -6053, -6957, -7815, -8630, -9407, -10144, -10844, -11511, -12141, -12738, -13305, -13841, -14347, -14828, -15279, -15705, -16106, -16482, -16837, -17169, -17479, -17768, -18038, -18289, -18521, -18735, -18932, -19113, -19278, -19427, -19562, -19682, -19787, -19881, -19961, -20028, -20084, -20127, -20160, -20181, -20193, -20193, -20184, -20166, -20138, -20102, -20057, -20004, -19942, -19873, -19796, -19712, -19621, -19522, -19418, -19307, -19189, -19066, -18937, -18801, -18661, -18515, -18364, -18208, -18047, -17882, -17712, -17538, -17358, -17176, -16989, -16797, -16602, -16404, -16202, -15997, -15788, -15575, -15360, -15142, -14920, -14696, -14468, -14237, -14005, -13771, -13532, -13292, -13050, -12804, -12558, -12309, -12056, -11803, -11548, -11290, -11031, -10769, -10506, -10242, -9975, -9707, -9438, -9167, -8894, -8620, -8344, -8068, -7789, -7510, -7229, -6947, -6663, -6380, -6094, -5807, -5520, -5231, -4941, -4651, -4359, -4066, -3773, -3478, -3183, -2887, -2590, -2292, -1994, -1694, -1394, -1094, -793, -492, -184};