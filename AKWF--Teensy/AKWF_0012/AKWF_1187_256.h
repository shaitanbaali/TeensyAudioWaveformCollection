/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1187 256 samples */
 
const int16_t AKWF_1187_256_DATA [256] = 
{12450, 32811, 29161, 20274, 15214, 14019, 13424, 12590, 11528, 12319, 12397, 11178, 9648, 9362, 9432, 7770, 6966, 8549, 10344, 10742, 9544, 8565, 7386, 6303, 5284, 6111, 6037, 5665, 5415, 4515, 2441, 441, 4190, 8806, 10217, 9498, 8938, 9912, 9389, 8059, 6805, 7649, 7804, 6589, 5004, 4636, 4617, 2862, 1962, 3445, 5137, 5432, 4151, 2978, 2209, 3052, 2716, 2956, 2292, 571, -1178, -2166, -3966, -5642, 1055, 6909, 7665, 6990, 6444, 6476, 5961, 5199, 4258, 6598, 8534, 7390, 5221, 4452, 4336, 2625, 1784, 3306, 5032, 5361, 4097, 3053, 1809, 661, -422, 340, 203, -232, -546, -1509, -3645, -5707, -2020, 2533, 3885, 3106, 2485, 3401, 2820, 1431, 119, 907, 1004, -240, -2010, -1351, 789, -467, -1951, -1103, 230, 357, -1053, -2240, -3621, -4894, -6088, -5436, -5588, -7107, -8873, -9914, -11836, -13451, -1206, 8174, 7243, 4453, 3225, 3601, 3670, 3357, 2806, 4017, 4387, 3354, 1944, 1732, 1849, 209, -562, 887, 3489, 6133, 5677, 4198, 2378, 920, -265, 464, 299, -161, -490, -1454, -3582, -5630, -1924, 2650, 4024, 3267, 2672, 3613, 3057, 1694, 409, 1221, 1345, 99, -1516, -1915, -1964, -3749, -4678, -3226, -1563, -1297, -2608, -3811, -4608, -3793, -4158, -3948, -4640, -6389, -8167, -9183, -11011, -12715, -6045, -218, 509, -192, -765, -760, -1301, -2090, -3058, -745, 1164, -6, -2201, -2996, -3137, -4875, -5741, -4245, -2546, -2241, -3530, -4598, -5868, -7041, -8149, -7410, -7572, -8033, -8371, -9358, -11518, -13604, -9940, -5410, -4082, -4885, -5528, -4635, -5240, -6652, -7986, -7221, -7147, -8440, -10103, -10549, -10644, -12475, -13450, -12044, -10426, -10204, -11579, -12735, -14089, -15345, -16537, -15892, -16056, -17592, -19379, -20332, -23026, -20421};