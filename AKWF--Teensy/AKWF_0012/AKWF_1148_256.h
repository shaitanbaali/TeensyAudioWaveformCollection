/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1148 256 samples */
 
const int16_t AKWF_1148_256_DATA [256] = 
{7602, 6879, 7055, 7030, 7038, 7044, 7049, 7053, 7058, 7060, 7064, 7066, 7070, 7209, 6485, 9272, 29932, 30916, 30597, 30671, 30665, 30470, 31277, 28117, -13208, -19963, -18550, -18832, -18836, -18777, -18912, -18500, 2274, 7786, 6621, 6843, 6843, 6843, 6843, 6842, 6842, 6840, 6839, 6839, 6838, 6833, 6906, 6529, 9558, 11497, 11175, 11231, 11229, 11226, 11223, 11221, 11218, 11215, 11212, 11209, 11206, 11203, 11199, 11195, 11192, 11189, 11185, 11181, 11177, 11174, 11170, 11166, 11162, 11158, 11154, 11150, 11146, 11142, 11138, 11134, 11130, 11126, 11122, 11118, 11114, 11109, 11106, 11101, 11097, 11093, 11089, 11085, 11081, 11077, 11073, 11068, 11064, 11060, 11057, 11052, 11048, 11044, 11040, 11036, 11031, 11027, 11023, 11019, 11015, 11011, 11007, 11003, 10998, 10994, 10990, 10986, 10982, 10978, 10974, 10970, 10966, 10962, 10957, 10953, 10948, 10889, 11186, 9577, 6293, 6576, 6524, 6519, 6516, 6512, 6510, 6507, 6504, 6501, 6498, 6496, 6494, 6468, 6590, 6110, 2563, 2392, 2444, 2430, 2429, 2461, 2320, 2862, 9952, 11105, 10861, 10907, 10906, 10894, 10896, 10920, 6494, 6007, 6280, 6222, 6218, 6214, 6212, 6207, 6206, 6203, 6199, 6198, 6194, 6211, 5780, 7966, -9680, -20995, -19140, -19473, -19473, -19470, -19465, -19460, -19455, -19449, -19442, -19435, -19428, -19419, -19410, -19402, -19392, -19383, -19373, -19364, -19353, -19344, -19334, -19324, -19313, -19301, -19292, -19279, -19268, -19258, -19245, -19235, -19223, -19211, -19201, -19189, -19178, -19165, -19154, -19142, -19131, -19118, -19107, -19095, -19083, -19071, -19059, -19047, -19035, -19023, -19013, -19000, -18988, -18976, -18964, -18953, -18940, -18928, -18916, -18905, -18893, -18880, -18869, -18857, -18845, -18833, -18822, -18809, -18797, -18785, -18774, -18762, -18750, -18738, -18726, -18714, -18699, -18405, -19917, -11436};