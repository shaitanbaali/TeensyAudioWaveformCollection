/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1109 256 samples */
 
const int16_t AKWF_1109_256_DATA [256] = 
{1619, 4161, 6257, 7663, 8210, 8801, 10221, 11571, 13050, 14726, 16152, 17659, 19142, 20629, 22077, 23484, 24551, 26003, 27565, 28177, 28779, 29877, 30686, 31375, 32237, 32715, 32694, 31930, 31505, 31410, 30626, 29815, 29704, 29419, 28719, 28590, 28653, 28192, 27470, 26976, 26186, 24895, 23539, 22983, 22179, 20503, 19286, 18526, 17254, 15896, 15396, 15277, 15090, 15091, 15402, 15623, 15761, 15862, 16860, 17503, 17514, 17824, 17409, 16459, 15702, 15752, 15593, 15197, 15148, 15449, 15464, 15926, 17396, 18705, 19236, 19706, 19887, 19827, 19709, 20075, 20663, 20789, 20421, 19392, 18690, 18002, 16677, 16100, 15978, 14722, 13000, 10109, 7336, 5540, 4759, 2994, 1060, -893, -3659, -5091, -6655, -8490, -11140, -13437, -15414, -16803, -17601, -18362, -20580, -22936, -22903, -22974, -22816, -21832, -21493, -21997, -22112, -21673, -21328, -20950, -20429, -19658, -19068, -19153, -19000, -18476, -17926, -16777, -15419, -14374, -13157, -11938, -10752, -9555, -7872, -6161, -5278, -4458, -3985, -4233, -4473, -4865, -5519, -5809, -6472, -7638, -8909, -9730, -10648, -11406, -11415, -11459, -11737, -12560, -12976, -13122, -13917, -14567, -14718, -15640, -17578, -19315, -19885, -20787, -22086, -22286, -22467, -24018, -25585, -26027, -26473, -27008, -26884, -26446, -26739, -27383, -27494, -27224, -27664, -28545, -28857, -27944, -27124, -25305, -23122, -22158, -20450, -19207, -18489, -17322, -15770, -15050, -14444, -13599, -12586, -11570, -11316, -11497, -9276, -8535, -9141, -9100, -8945, -8976, -8759, -8002, -7127, -6299, -6221, -6787, -6881, -6578, -6311, -6030, -5855, -6401, -7936, -9350, -10376, -11646, -13092, -13758, -14944, -16773, -18355, -20416, -21591, -22462, -23788, -24470, -24540, -25161, -26593, -26628, -26057, -25032, -23771, -23464, -23690, -23224, -22564, -20934, -18454, -17009, -15101, -13275, -12578, -11772, -9607, -7959, -6739, -4972, -3841, -2988, -2135, -1125};