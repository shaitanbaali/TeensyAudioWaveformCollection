/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1158 256 samples */
 
const int16_t AKWF_1158_256_DATA [256] = 
{317, 868, 1417, 1977, 2546, 3129, 3724, 4329, 4949, 5585, 6232, 6895, 7573, 8264, 8972, 9694, 10428, 11178, 11940, 12712, 13497, 14291, 15091, 15900, 16713, 17527, 18347, 19163, 19976, 20786, 21588, 22379, 23160, 23925, 24674, 25406, 26113, 26797, 27455, 28084, 28682, 29247, 29776, 30267, 30720, 31131, 31499, 31823, 32101, 32333, 32516, 32649, 32733, 32767, 32751, 32683, 32564, 32395, 32174, 31904, 31585, 31217, 30802, 30340, 29832, 29282, 28689, 28054, 27392, 26733, 26087, 25470, 24894, 24358, 23874, 23439, 23044, 22691, 22376, 22098, 21851, 21630, 21433, 21254, 21088, 20931, 20781, 20599, 20370, 20084, 19720, 19277, 18749, 18130, 17430, 16652, 15796, 14868, 13871, 12810, 11694, 10526, 9312, 8062, 6792, 5538, 4313, 3134, 2016, 965, -13, -914, -1742, -2502, -3188, -3803, -4352, -4838, -5263, -5634, -5955, -6227, -6463, -6698, -6948, -7227, -7553, -7929, -8367, -8868, -9429, -10049, -10727, -11465, -12261, -13104, -13999, -14940, -15920, -16925, -17918, -18890, -19824, -20707, -21533, -22297, -22994, -23631, -24208, -24722, -25173, -25567, -25903, -26184, -26413, -26592, -26723, -26809, -26851, -26851, -26811, -26734, -26622, -26475, -26298, -26090, -25854, -25593, -25309, -25002, -24676, -24331, -23968, -23591, -23199, -22793, -22376, -21945, -21504, -21054, -20591, -20119, -19637, -19144, -18642, -18130, -17607, -17075, -16559, -16079, -15641, -15262, -14941, -14681, -14487, -14350, -14262, -14221, -14224, -14264, -14335, -14430, -14544, -14673, -14810, -14949, -15088, -15221, -15346, -15458, -15557, -15637, -15697, -15735, -15749, -15738, -15700, -15635, -15542, -15419, -15269, -15091, -14885, -14651, -14391, -14106, -13797, -13465, -13112, -12739, -12347, -11939, -11517, -11081, -10634, -10177, -9709, -9237, -8757, -8273, -7786, -7293, -6800, -6305, -5807, -5308, -4810, -4308, -3806, -3303, -2797, -2287, -1776, -1260, -740, -203};