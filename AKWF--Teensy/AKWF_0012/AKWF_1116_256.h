/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1116 256 samples */
 
const int16_t AKWF_1116_256_DATA [256] = 
{6328, 16183, 16214, 15019, 14904, 14063, 5987, -428, -3767, -3170, 1303, 1108, 2890, -961, -6607, -9819, -6392, -914, -462, -224, 3538, 4382, 3086, 1607, 1522, 1456, 4195, 2862, 1897, 2750, 1057, -4839, -7610, -4758, -887, -1295, -6232, -4432, -3221, -7639, -9916, -7250, 1501, 4751, 1818, 4891, 7474, 3933, 413, 2476, 3924, -587, -5367, -3868, 4446, 3896, 747, 3161, 3191, 2141, -1986, -16675, -22447, -5864, 7828, 11300, 8472, 5848, 4873, 7961, 7227, 6304, 3310, 1515, -2750, -5561, -3312, -4200, -3505, -4431, -2843, 5, -1555, -1207, 686, 541, 1597, 2693, 4041, 3053, 1133, -933, -164, 1711, 4585, 3013, 603, -690, 62, -1118, -5348, -4015, -703, -4097, -8242, -8089, -4556, -4781, -1584, 4386, 7713, 2530, 199, 3084, 4183, -1226, -5705, -5483, 974, 3440, 4066, 6753, 4844, 1830, -2171, -12349, -21837, -19083, -3632, 9965, 15543, 14556, 11197, 7121, 3160, -591, -1870, 1965, 5616, 5527, 4385, -1874, -4576, -6314, -4156, 3084, 4804, 3162, 3739, -207, -1126, -1654, -2468, 685, 1768, -2810, -6007, -6746, -4655, -3597, -5387, -444, 4318, 4239, 442, -1414, -1645, -2911, -4293, -181, 4351, 1313, -1477, 11, 2353, -892, -3226, -1796, 1443, -1807, -2996, -4061, 320, 2793, 3632, 8080, 8452, 6345, 902, -1180, 2066, 636, 719, 2972, 1193, -3048, -1705, -295, -2890, -5260, -7469, -6651, -4130, -3632, -939, -127, 1649, 598, 930, 5098, 6465, 3290, 3690, 2943, 1786, 1792, 1155, -579, -170, -1698, -2910, -1613, 972, 385, -2604, -674, 3765, 2236, -1151, 1074, 2623, -1750, -6524, -4161, 657, 1786, -1377, 2244, 5207, 949, -4111, -4241, -351, -2647, -4714, -5217, -1771, -1811, -2371, 3651, 6127, 3990, -634, -14193, -31271, -11790};