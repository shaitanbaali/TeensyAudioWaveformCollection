/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1111 256 samples */
 
const int16_t AKWF_1111_256_DATA [256] = 
{513, 1692, 2707, 3546, 4405, 5440, 6577, 7640, 8664, 9505, 10213, 10826, 11318, 11736, 12276, 12984, 13782, 14388, 14783, 15251, 15737, 16475, 17449, 18259, 19105, 19967, 20789, 21602, 22380, 23102, 23737, 24416, 25137, 25748, 26236, 26636, 27059, 27560, 27998, 28332, 28594, 28854, 29080, 29454, 29994, 30295, 30702, 31227, 31633, 31987, 32175, 32284, 32479, 32510, 32473, 32549, 32619, 32748, 32707, 32517, 32315, 32011, 31643, 31262, 30836, 30461, 30048, 29594, 29148, 28702, 28214, 27791, 27309, 26542, 25852, 25209, 24683, 24375, 24170, 24066, 23986, 23821, 23639, 23422, 23246, 23172, 23143, 23144, 22993, 22737, 22391, 21925, 21552, 21236, 21038, 20873, 20594, 20345, 20103, 19868, 19730, 19334, 18607, 17919, 17250, 16688, 16132, 15500, 14929, 14317, 13517, 12652, 11765, 10715, 9619, 8560, 7406, 6248, 5178, 4221, 3359, 2106, 134, -1038, -2181, -3099, -3608, -4011, -4541, -5088, -5595, -6255, -6767, -7266, -7808, -8420, -9051, -9724, -10510, -11313, -11931, -12367, -12790, -13267, -13816, -14418, -14903, -15313, -15771, -16231, -16637, -16984, -17432, -17853, -18374, -18968, -19389, -20007, -20770, -21649, -22586, -23303, -23919, -24414, -24858, -25460, -26183, -26780, -27140, -27446, -27702, -27998, -28308, -28574, -28934, -29252, -29479, -29755, -29883, -30135, -30780, -31307, -31589, -31713, -31596, -31480, -31301, -31146, -31183, -31193, -31124, -30954, -30715, -30394, -30144, -29798, -29265, -28729, -28209, -27748, -27382, -27141, -26937, -26682, -26387, -26082, -25602, -25143, -24766, -24514, -24466, -24328, -24233, -24118, -23856, -23663, -23550, -23462, -23292, -22961, -22637, -22277, -21906, -21613, -21053, -20319, -19694, -19155, -18808, -18549, -18326, -18202, -18027, -17722, -17283, -16788, -16212, -15419, -14581, -13659, -12666, -11658, -10746, -9833, -8911, -8069, -7289, -6537, -5853, -5233, -4607, -4056, -3612, -3177, -2366, -627};