/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1141 256 samples */
 
const int16_t AKWF_1141_256_DATA [256] = 
{342, 957, 1546, 2126, 2692, 3253, 3803, 4344, 4875, 5394, 5903, 6403, 6893, 7369, 7834, 8282, 8718, 9140, 9545, 9933, 10302, 10651, 10981, 11291, 11578, 11845, 12086, 12307, 12506, 12682, 12835, 12966, 13076, 13167, 13238, 13290, 13327, 13347, 13355, 13350, 13336, 13313, 13284, 13250, 13214, 13178, 13143, 13112, 13086, 13066, 13057, 13057, 13067, 13091, 13129, 13181, 13248, 13330, 13429, 13543, 13673, 13820, 13982, 14157, 14346, 14549, 14765, 14989, 15223, 15464, 15713, 15967, 16224, 16487, 16748, 17010, 17273, 17531, 17788, 18041, 18287, 18529, 18764, 18991, 19211, 19422, 19621, 19813, 19993, 20159, 20315, 20455, 20579, 20687, 20778, 20848, 20898, 20924, 20927, 20905, 20853, 20775, 20665, 20523, 20348, 20138, 19893, 19613, 19294, 18940, 18548, 18121, 17660, 17162, 16630, 16067, 15474, 14854, 14212, 13543, 12854, 12150, 11430, 10704, 9971, 9230, 8491, 7756, 7026, 6311, 5605, 4912, 4239, 3586, 2958, 2354, 1774, 1221, 698, 203, -259, -696, -1104, -1483, -1834, -2158, -2457, -2734, -2988, -3223, -3439, -3642, -3831, -4011, -4183, -4349, -4515, -4684, -4856, -5036, -5227, -5429, -5649, -5889, -6149, -6434, -6744, -7083, -7453, -7857, -8294, -8765, -9270, -9811, -10390, -11004, -11652, -12334, -13047, -13792, -14567, -15369, -16192, -17032, -17895, -18766, -19650, -20539, -21424, -22306, -23183, -24047, -24894, -25717, -26510, -27276, -28006, -28696, -29345, -29943, -30489, -30987, -31426, -31806, -32123, -32379, -32573, -32700, -32762, -32757, -32687, -32552, -32354, -32092, -31769, -31388, -30948, -30455, -29908, -29313, -28674, -27990, -27266, -26508, -25714, -24894, -24053, -23184, -22299, -21398, -20485, -19566, -18645, -17715, -16791, -15866, -14946, -14042, -13142, -12253, -11378, -10515, -9671, -8849, -8035, -7241, -6467, -5708, -4972, -4252, -3545, -2858, -2188, -1534, -892, -253};