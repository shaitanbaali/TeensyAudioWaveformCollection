/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1188 256 samples */
 
const int16_t AKWF_1188_256_DATA [256] = 
{13115, 30335, 32187, 27698, 25322, 26275, 23111, 18938, 23337, 22392, 21977, 24188, 23867, 18129, 8199, 6759, 21180, 25413, 18679, 10843, 9574, 14607, 16175, 14754, 18692, 13998, 7457, 3539, -693, -6822, -12965, -7533, 14583, 25211, 21488, 12297, 6203, 4582, 27, -4405, 738, 1347, 3038, 7640, 9711, 6090, -2207, -2671, 11975, 15668, 7696, -1938, -5381, -2659, -3285, -6542, -3859, -9057, -15243, -17916, -20060, -23369, -26156, -17063, 8762, 22865, 22134, 15241, 10586, 9462, 4455, -1296, 1802, -145, -1253, 573, 180, -5329, -14739, -15389, 69, 5560, 276, -5959, -5506, 1327, 4731, 5152, 10892, 7923, 3003, 564, -2360, -7368, -12599, -6480, 16095, 26948, 23221, 13805, 7279, 5038, -307, -5663, -1555, -2061, -1525, 1908, 2837, -1860, -11143, -12469, 1469, 4629, -3679, -13438, -16783, -13734, -13806, -16286, -12614, -16627, -21449, -22609, -23119, -24697, -25699, -14801, 12819, 28662, 29584, 24223, 20942, 21011, 16984, 11981, 15581, 13873, 12736, 14267, 13314, 6993, -3468, -5386, 8614, 12481, 5443, -2635, -4087, 825, 2333, 913, 4915, 344, -6015, -9693, -13631, -19411, -25155, -19275, 3336, 14500, 11353, 2775, -2675, -3623, -7483, -11198, -5322, -3969, -1528, 3827, 6650, 3774, -3786, -3529, 11818, 16193, 8873, -139, -2993, 281, 166, -2624, 481, -4343, -10206, -12608, -14537, -17683, -20366, -11224, 14594, 28632, 27780, 20710, 15823, 14414, 9068, 2931, 5595, 3167, 1537, 2802, 1810, -4329, -14400, -15735, -983, 3784, -2238, -9218, -9517, -3434, -776, -1094, 3920, 243, -5364, -8465, -12020, -17628, -23422, -17823, 4273, 14695, 10587, 841, -5959, -8420, -13927, -19384, -15319, -15805, -15189, -11612, -10478, -14911, -23871, -24812, -10433, -6777, -14535, -23694, -26390, -22647, -21983, -23687, -19204, -22378, -26329, -26596, -26194, -26898, -26978, -14694};