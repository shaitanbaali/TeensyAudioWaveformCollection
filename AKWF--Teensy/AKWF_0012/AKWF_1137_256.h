/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1137 256 samples */
 
const int16_t AKWF_1137_256_DATA [256] = 
{261, 819, 1124, 1271, 1299, 1245, 1137, 999, 845, 687, 536, 400, 284, 192, 136, 97, 92, 2964, 5421, 6930, 8296, 9492, 10567, 11558, 12471, 13320, 14118, 14865, 15563, 16224, 16843, 17427, 17975, 18492, 18977, 19430, 19854, 20249, 20615, 20953, 21265, 21548, 21806, 22036, 22241, 22419, 22572, 22700, 22802, 22877, 22880, 23138, 21830, 18283, 16216, 14534, 13093, 11817, 10658, 9603, 8633, 7731, 6899, 6124, 5402, 4737, 4120, 3550, 3026, 2546, 2109, 1718, 1366, 1057, 788, 560, 373, 226, 126, 52, 20, 2926, 5394, 6896, 8144, 9736, 9447, -18706, -23041, -22998, -23949, -24687, -25377, -26031, -26645, -27222, -27767, -28277, -28757, -29208, -29627, -30018, -30381, -30716, -31024, -31306, -31559, -31788, -31990, -32150, -31849, -34714, 10681, 25610, 22303, 23159, 21857, 18319, 16253, 14581, 13144, 11873, 10723, 9670, 8702, 7806, 6974, 6204, 5486, 4822, 4207, 3639, 3117, 2639, 2204, 1813, 1463, 1155, 887, 660, 474, 327, 228, 155, 126, 3038, 5497, 7001, 8352, 9530, 10591, 11566, 12466, 13304, 14090, 14825, 15518, 16169, 16783, 17360, 17906, 18418, 18898, 19349, 19770, 20162, 20527, 20864, 21173, 21456, 21712, 21942, 22146, 22324, 22477, 22604, 22704, 22781, 22782, 23043, 21711, 18181, 16113, 14434, 12991, 11715, 10558, 9504, 8531, 7633, 6798, 6023, 5304, 4638, 4020, 3450, 2926, 2446, 2011, 1617, 1268, 958, 689, 462, 89, 932, -4989, -10908, -9879, -12979, -15445, -16942, -18294, -19471, -20531, -21508, -22408, -23241, -24027, -24760, -25450, -26103, -26714, -27290, -27833, -28342, -28821, -29271, -29688, -30079, -30440, -30775, -31083, -31363, -31617, -31844, -32046, -32221, -32371, -32496, -32595, -32669, -32667, -32925, -31592, -28054, -25985, -24254, -23034, -20538, -14332, -9555, -6117, -3597, -1812, -555};