/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1120 256 samples */
 
const int16_t AKWF_1120_256_DATA [256] = 
{254, 625, 975, 1322, 1668, 2018, 2365, 2705, 3038, 3362, 3684, 4008, 4340, 4686, 5049, 5433, 5846, 6299, 6801, 7362, 7998, 8718, 9528, 10440, 11449, 12550, 13732, 14976, 16255, 17549, 18839, 20102, 21304, 22400, 23369, 24210, 24954, 25655, 26346, 27017, 27636, 28177, 28645, 29078, 29505, 29935, 30357, 30756, 31121, 31456, 31762, 32034, 32269, 32464, 32615, 32719, 32766, 32757, 32702, 32616, 32511, 32382, 32215, 31998, 31735, 31436, 31099, 30699, 30206, 29612, 28940, 28219, 27459, 26650, 25779, 24834, 23821, 22761, 21676, 20595, 19534, 18485, 17476, 16603, 15953, 15493, 15062, 14523, 13889, 13267, 12741, 12317, 11934, 11529, 11091, 10631, 10152, 9666, 9187, 8723, 8267, 7800, 7331, 6891, 6493, 6138, 5813, 5495, 5168, 4831, 4486, 4150, 3834, 3538, 3257, 2987, 2712, 2430, 2139, 1838, 1525, 1205, 885, 572, 262, -52, -375, -705, -1033, -1359, -1689, -2032, -2389, -2760, -3140, -3526, -3918, -4306, -4678, -5036, -5395, -5766, -6150, -6540, -6917, -7272, -7604, -7932, -8271, -8624, -8980, -9329, -9661, -9984, -10304, -10622, -10938, -11247, -11545, -11836, -12123, -12400, -12664, -12912, -13191, -13724, -14817, -16483, -18314, -19841, -20952, -21917, -23020, -24317, -25636, -26745, -27547, -28101, -28505, -28843, -29185, -29527, -29791, -29898, -29867, -29810, -29818, -29911, -30039, -30146, -30178, -30113, -29958, -29754, -29551, -29368, -29202, -29034, -28838, -28593, -28300, -27961, -27569, -27121, -26645, -26169, -25687, -25181, -24643, -24084, -23537, -23029, -22555, -22082, -21579, -21027, -20429, -19794, -19133, -18482, -17872, -17302, -16746, -16162, -15534, -14885, -14259, -13694, -13204, -12749, -12265, -11720, -11133, -10558, -10025, -9522, -9014, -8473, -7899, -7318, -6757, -6222, -5705, -5197, -4696, -4218, -3765, -3321, -2878, -2442, -2027, -1639, -1266, -890, -506, -115};