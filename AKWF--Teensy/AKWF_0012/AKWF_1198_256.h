/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1198 256 samples */
 
const int16_t AKWF_1198_256_DATA [256] = 
{6399, 7242, 6612, 9344, 12988, 12609, 12254, 14290, 20292, 20038, 19835, 20784, 27921, 28201, 28105, 28122, 28117, 28110, 28135, 27963, 28660, 32279, 32368, 32321, 32321, 32309, 32296, 32283, 32270, 32256, 32242, 32228, 32214, 32045, 32876, 28578, 18814, 19653, 19996, 19959, 19461, 19290, 19327, 19312, 19287, 19499, 13384, 11566, 11980, 11814, 14743, 15711, 15505, 15543, 15542, 15525, 15544, 15560, 9275, 7830, 8161, 8099, 8096, 8095, 8094, 8157, 7806, 9701, 12638, 12306, 12311, 12567, 13072, 13010, 13005, 13062, 12783, 11679, 11593, 12126, 6633, 3779, 4373, 4099, 4792, 8454, 7975, 8259, 5789, -691, -183, -283, -292, -299, -307, -325, -279, -1003, 101, -3965, -13720, -13123, -13215, -13220, -13215, -13209, -13202, -13194, -13186, -13178, -13296, -12591, -16023, -21966, -17918, -16746, -17000, -16945, -16937, -16849, -17307, -11595, -9046, -9610, -9278, -8788, -8874, -8767, -2417, -1076, -1774, 529, 3841, 3526, 3160, 5197, 11200, 10900, 10940, 10945, 10943, 10940, 10937, 10934, 10930, 10927, 10954, 10785, 11482, 15132, 14652, 14447, 14486, 14471, 14433, 14567, 14042, 6861, 6171, 6343, 6298, 6135, 6971, 2678, -7080, -6235, -5889, -5901, -6465, -7231, -7219, -7219, -7239, -7020, -13129, -14941, -14519, -14679, -11743, -10768, -10967, -10924, -10918, -10927, -10902, -10880, -17156, -18596, -18257, -18312, -18302, -18329, -18186, -17534, -17892, -15988, -13044, -13379, -13313, -13310, -13308, -13306, -13309, -13284, -13383, -13916, -14024, -13479, -18966, -21813, -21212, -21478, -20778, -17109, -17484, -17741, -17687, -17696, -17697, -17699, -17702, -17704, -17705, -17708, -17705, -17892, -16554, -20662, -30403, -29801, -29888, -29888, -29877, -29866, -29854, -29842, -29780, -30027, -28976, -21835, -21589, -21800, -18451, -17135, -17430, -17170, -16611, -16561, -17008, -11295, -8607, -9914, -5643, 229, -538, -560};