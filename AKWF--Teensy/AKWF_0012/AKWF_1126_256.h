/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1126 256 samples */
 
const int16_t AKWF_1126_256_DATA [256] = 
{424, 1279, 2116, 2953, 3792, 4628, 5468, 6306, 7144, 7982, 8820, 9628, 10411, 11186, 11950, 12710, 13458, 14200, 14932, 15655, 16371, 17079, 17776, 18467, 19150, 19832, 20499, 21154, 21803, 22443, 23073, 23696, 24311, 24917, 25514, 26103, 26681, 27260, 27782, 28176, 28550, 28909, 29252, 29577, 29885, 30178, 30451, 30709, 30951, 31177, 31387, 31574, 31774, 31959, 32098, 32224, 32334, 32426, 32501, 32562, 32598, 32406, 33514, 27616, -27467, -31015, -28791, -28079, -27128, -26191, -25269, -24517, -23866, -23209, -22562, -21924, -21295, -20672, -20059, -19452, -18853, -18264, -17681, -17106, -16551, -15939, -15212, -14511, -13822, -13154, -12498, -11860, -11239, -10636, -10048, -9477, -8921, -8386, -7861, -7416, -7045, -6676, -6318, -5968, -5626, -5291, -4967, -4650, -4341, -4042, -3748, -3466, -3182, -2940, -2741, -2537, -2334, -2132, -1929, -1726, -1523, -1321, -1118, -916, -713, -511, -309, -107, 95, 296, 498, 702, 903, 1104, 1306, 1507, 1708, 1911, 2113, 2314, 2513, 2742, 3007, 3277, 3555, 3843, 4138, 4442, 4754, 5074, 5402, 5738, 6083, 6435, 6795, 7155, 7530, 7916, 8310, 8710, 9120, 9539, 9963, 10399, 10841, 11291, 11752, 12213, 12717, 13360, 14033, 14720, 15425, 16141, 16879, 17631, 18399, 19187, 19990, 20805, 21642, 22496, 23340, 24196, 25099, 26011, 26945, 27894, 28857, 29573, 31863, 28121, -28977, -33811, -32492, -32736, -32674, -32578, -32505, -32410, -32298, -32170, -32025, -31863, -31683, -31487, -31274, -31042, -30796, -30536, -30243, -29915, -29604, -29273, -28928, -28564, -28184, -27788, -27374, -26945, -26501, -26036, -25557, -25062, -24552, -23945, -23273, -22600, -21919, -21230, -20531, -19825, -19109, -18386, -17657, -16918, -16170, -15414, -14664, -13852, -13005, -12165, -11321, -10479, -9639, -8795, -7956, -7112, -6272, -5433, -4590, -3750, -2912, -2071, -1235, -380};