/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1131 256 samples */
 
const int16_t AKWF_1131_256_DATA [256] = 
{146, 598, 10768, 12888, 12505, 12698, 12803, 12906, 13010, 13114, 13218, 13322, 13425, 13528, 13631, 13735, 13838, 13941, 14044, 14147, 14250, 14355, 14458, 14560, 14664, 14767, 14871, 14975, 15078, 15181, 15285, 15389, 15492, 15596, 15699, 15804, 15908, 16012, 16117, 16221, 16325, 16429, 16535, 16639, 16744, 16848, 16953, 17058, 17163, 17268, 17372, 17478, 17584, 17690, 17794, 17901, 18005, 18112, 18217, 18323, 18428, 18535, 18640, 18747, 18851, 18967, 19026, 18922, 18813, 18704, 18596, 18486, 18378, 18268, 18159, 18050, 17940, 17831, 17721, 17611, 17501, 17391, 17281, 17171, 17061, 16951, 16840, 16731, 16620, 16509, 16397, 16286, 16176, 16065, 15956, 15843, 15732, 15620, 15509, 15398, 15287, 15174, 15063, 14951, 14839, 14728, 14615, 14503, 14390, 14279, 14167, 14054, 13941, 13829, 13716, 13604, 13491, 13378, 13265, 13152, 13038, 12926, 12812, 12699, 12585, 12471, 12359, 12245, 12132, 12017, 11903, 11790, 11550, 12143, 8954, -2790, -2942, -3524, -4057, -4585, -5110, -5634, -6157, -6681, -7203, -7726, -8249, -8766, -9288, -9809, -10329, -10849, -11367, -11883, -12403, -12920, -13436, -13956, -14470, -14985, -15502, -16018, -16532, -17050, -17560, -18076, -18590, -19103, -19617, -20128, -20639, -21153, -21666, -22177, -22690, -23198, -23710, -24222, -24732, -25242, -25752, -26261, -26770, -27279, -27788, -28297, -28805, -29313, -29819, -30329, -30833, -31340, -31838, -32385, -32665, -32152, -31613, -31080, -30544, -30010, -29473, -28939, -28405, -27870, -27333, -26798, -26264, -25733, -25198, -24663, -24129, -23595, -23062, -22531, -21998, -21464, -20931, -20399, -19870, -19337, -18807, -18274, -17742, -17212, -16684, -16151, -15622, -15092, -14561, -14035, -13504, -12975, -12447, -11918, -11391, -10865, -10335, -9808, -9281, -8753, -8230, -7702, -7176, -6650, -6126, -5601, -5077, -4550, -4025, -3501, -2979, -2455, -1932, -1408, -886, -355};