/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1110 256 samples */
 
const int16_t AKWF_1110_256_DATA [256] = 
{-54, 405, 1414, 1852, 1645, 823, 19, -194, -94, 765, 1565, 1946, 2512, 3130, 3539, 3972, 4125, 3225, 2075, -62, -2462, -3122, -2955, -2568, -2599, -3127, -4123, -4954, -5701, -6688, -7023, -6292, -5085, -3858, -2819, -2061, -1619, -848, 165, 738, 757, 496, 31, -472, -234, -36, -797, -1112, -1208, -1029, -244, 748, 2213, 3831, 5446, 6924, 8053, 8951, 9381, 9667, 10119, 10567, 10653, 9844, 8531, 7378, 6966, 6742, 6442, 6056, 5868, 6147, 6786, 7147, 7221, 7460, 6966, 5144, 4189, 3385, 2710, 2108, 1680, 1278, 715, -181, -1621, -3094, -4484, -5728, -6489, -7042, -8158, -9196, -10117, -10485, -10347, -10356, -10626, -11421, -12161, -12753, -13397, -14208, -15261, -15999, -16443, -17356, -18544, -19500, -19953, -19543, -18744, -18017, -17537, -17363, -17013, -16487, -15993, -15582, -15622, -16196, -16203, -15176, -14608, -14364, -14088, -14127, -14191, -14570, -15460, -15956, -16432, -17012, -17091, -16857, -16409, -16336, -16800, -16986, -17113, -17264, -17570, -18420, -19476, -20225, -20967, -21943, -22763, -23755, -26082, -27270, -29477, -31435, -31909, -31542, -31067, -31209, -31491, -31806, -32024, -32240, -32634, -32761, -32566, -32381, -32296, -32340, -32053, -30620, -27562, -26184, -26374, -27260, -27853, -28094, -27771, -27149, -25986, -24138, -22242, -21158, -19739, -17788, -16869, -16368, -16122, -15891, -16189, -16394, -16487, -15875, -14429, -13103, -12111, -11502, -11285, -11378, -10977, -8528, -6388, -6053, -6744, -7827, -8966, -9498, -9127, -8773, -8736, -8769, -9133, -9901, -10323, -9984, -9229, -8109, -7222, -6976, -7401, -7766, -7765, -7556, -7449, -7472, -7821, -8275, -8122, -6140, -4037, -3922, -4577, -5463, -6167, -6584, -6489, -5845, -4637, -3609, -3556, -3943, -4449, -4727, -4528, -4218, -3924, -4441, -5492, -6203, -5876, -4517, -3165, -2478, -1830, -1328, -1033, -301};