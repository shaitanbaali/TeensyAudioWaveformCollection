/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1132 256 samples */
 
const int16_t AKWF_1132_256_DATA [256] = 
{219, 922, 1366, 1583, 1496, 1697, 2695, 3913, 5369, 7072, 8207, 8941, 9724, 10491, 11251, 12004, 12745, 13485, 14215, 14936, 15650, 16351, 17040, 17724, 18397, 19054, 19703, 20340, 20964, 21578, 22178, 22760, 23333, 23890, 24434, 24963, 25477, 25972, 26456, 26923, 27373, 27809, 28224, 28623, 29008, 29373, 29721, 30049, 30359, 30654, 30929, 31186, 31425, 31642, 31841, 32021, 32182, 32324, 32447, 32549, 32632, 32695, 32738, 32762, 32767, 32750, 32716, 32661, 32586, 32492, 32378, 32245, 32092, 31920, 31729, 31518, 31289, 31041, 30774, 30487, 30187, 29863, 29522, 29165, 28789, 28397, 27988, 27561, 27117, 26657, 26182, 25692, 25187, 24662, 24124, 23573, 23008, 22430, 21838, 21246, 20572, 20222, 21766, 23595, 25102, 26663, 26464, 23271, 20187, 17305, 14542, 12984, 12315, 11551, 10792, 10032, 9263, 8488, 7713, 6934, 6145, 5356, 4561, 3764, 2972, 2171, 1370, 570, -232, -920, -1367, -1583, -1498, -1704, -2698, -3917, -5375, -7073, -8211, -8944, -9725, -10492, -11252, -12007, -12752, -13485, -14217, -14938, -15650, -16354, -17044, -17725, -18398, -19058, -19708, -20345, -20966, -21579, -22179, -22765, -23337, -23893, -24435, -24966, -25478, -25976, -26459, -26923, -27374, -27809, -28227, -28628, -29010, -29372, -29721, -30050, -30362, -30656, -30931, -31186, -31424, -31643, -31842, -32021, -32184, -32326, -32447, -32551, -32632, -32695, -32740, -32763, -32766, -32752, -32716, -32661, -32588, -32494, -32377, -32245, -32092, -31921, -31729, -31518, -31290, -31042, -30774, -30488, -30184, -29862, -29524, -29166, -28791, -28396, -27986, -27559, -27118, -26657, -26182, -25691, -25184, -24662, -24126, -23574, -23008, -22429, -21834, -21247, -20573, -20222, -21770, -23598, -25109, -26671, -26473, -23265, -20177, -17308, -14537, -12985, -12316, -11549, -10794, -10033, -9264, -8490, -7713, -6930, -6147, -5358, -4564, -3768, -2969, -2173, -1377, -559};