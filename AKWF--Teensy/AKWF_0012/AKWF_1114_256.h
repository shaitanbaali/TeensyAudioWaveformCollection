/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1114 256 samples */
 
const int16_t AKWF_1114_256_DATA [256] = 
{424, 1697, 2909, 4049, 5117, 6192, 7340, 8527, 9612, 10510, 11247, 11930, 12599, 13190, 13700, 14283, 14903, 15519, 16265, 17024, 17860, 18932, 20093, 21182, 22077, 22782, 23489, 24124, 24646, 25200, 25809, 26360, 26737, 26971, 27093, 27156, 27229, 27322, 27351, 27328, 27295, 27255, 27199, 27121, 27019, 26894, 26800, 26646, 26428, 26173, 25928, 25788, 25710, 25676, 25737, 25843, 25992, 26205, 26477, 26829, 27203, 27552, 27862, 28088, 28238, 28333, 28436, 28550, 28716, 29022, 29448, 29930, 30432, 30921, 31373, 31789, 32116, 32377, 32561, 32707, 32767, 32706, 32576, 32408, 32121, 31767, 31391, 30941, 30449, 30012, 29569, 29057, 28538, 28049, 27565, 26873, 25144, 23323, 21631, 20206, 18983, 17902, 16805, 15653, 14485, 13244, 12043, 10946, 9931, 8978, 8101, 7252, 6342, 5363, 4482, 3763, 3104, 2387, 1558, 587, -412, -1292, -2053, -2722, -3317, -3916, -4551, -5196, -5826, -6391, -6848, -7242, -7626, -8066, -8582, -9059, -9480, -9834, -10065, -10253, -10543, -10936, -11290, -11591, -11835, -12086, -12391, -12730, -13080, -13432, -13744, -13969, -14110, -14203, -14438, -14790, -15140, -15516, -15833, -16004, -16071, -16138, -16275, -16422, -16558, -16728, -16944, -17152, -17405, -17600, -17565, -17429, -17317, -17293, -17362, -17567, -17920, -18337, -18763, -19168, -19498, -19803, -20149, -20608, -21208, -21798, -22371, -22896, -23309, -23690, -24101, -24575, -24987, -25239, -25446, -25665, -25913, -26249, -26459, -26348, -26103, -25861, -25686, -25567, -25493, -25516, -25634, -25721, -25662, -25525, -25343, -24956, -24346, -23607, -22836, -21998, -21181, -20443, -19722, -19036, -18465, -17981, -17513, -17140, -16941, -16863, -16862, -16944, -16998, -17006, -16901, -16679, -16251, -15631, -14899, -14079, -13171, -12226, -11345, -10546, -9799, -9115, -8537, -8086, -7646, -7134, -6521, -5890, -5385, -4894, -4435, -3917, -3241, -2556, -1749, -716};