/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1197 256 samples */
 
const int16_t AKWF_1197_256_DATA [256] = 
{232, 928, 1591, 2216, 2804, 3397, 4030, 4684, 5285, 5788, 6204, 6593, 6976, 7317, 7616, 7955, 8315, 8672, 9100, 9536, 10038, 10516, 11848, 14333, 15751, 16926, 18000, 18966, 19818, 20651, 21480, 22251, 22906, 23463, 23940, 24371, 24788, 25202, 25570, 25895, 26203, 26496, 26768, 27020, 27248, 27455, 27670, 27844, 27974, 28079, 28182, 28333, 28512, 28708, 28949, 29210, 29488, 29797, 30131, 30507, 30891, 31259, 31603, 31901, 32155, 32376, 32622, 32738, 32572, 32466, 32422, 32403, 32392, 32369, 32324, 32256, 32139, 31986, 31789, 31571, 31307, 30976, 30609, 30224, 29773, 28805, 30901, 14129, -220, 2603, 2340, 2511, 2667, 2825, 2971, 2993, 2448, 1840, 1290, 869, 544, 281, 0, -324, -667, -1060, -1445, -1785, -2091, -2375, -2627, -2875, -3165, -3502, -3794, -4011, -4202, -4433, -4731, -5114, -5519, -5866, -6158, -6407, -6621, -6845, -7094, -7353, -7609, -7835, -8008, -8151, -8293, -8468, -8687, -8890, -9065, -9207, -9286, -9344, -9457, -9628, -9782, -9905, -10001, -10103, -10233, -10381, -10562, -10590, -11428, -13390, -14236, -14880, -15464, -16013, -16488, -16922, -17274, -17510, -17654, -17768, -17892, -17997, -18075, -18150, -18233, -18297, -18370, -18398, -18292, -18122, -17955, -17825, -17737, -17716, -17767, -17846, -17926, -17988, -18007, -18009, -18031, -18109, -18261, -18405, -18538, -18644, -18691, -18718, -18760, -18836, -18877, -18834, -18770, -18686, -18565, -18499, -18374, -18087, -17736, -17394, -17096, -16838, -16611, -16443, -16335, -16217, -16029, -15807, -15567, -15226, -14772, -14255, -13728, -13172, -12633, -12142, -11666, -11213, -10830, -10497, -10177, -9914, -9746, -9650, -9598, -9594, -9579, -9543, -9450, -9298, -9037, -8677, -8259, -7797, -7290, -6765, -6276, -5832, -5418, -5038, -4716, -4462, -4215, -3931, -3592, -3244, -2964, -2691, -2435, -2147, -1774, -1396, -954, -388};