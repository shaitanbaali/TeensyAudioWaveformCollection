/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1176 256 samples */
 
const int16_t AKWF_1176_256_DATA [256] = 
{153, 535, 910, 1289, 1670, 2053, 2438, 2824, 3211, 3601, 3990, 4381, 4773, 5164, 5557, 5950, 6323, 6614, 6751, 6692, 6458, 6146, 5876, 5773, 6016, 6884, 8555, 10854, 13268, 15135, 15976, 15730, 14721, 13481, 12510, 12115, 12358, 13107, 14138, 15220, 16191, 16962, 17514, 17882, 18125, 18310, 18496, 18731, 19040, 19429, 19888, 20390, 20909, 21420, 21903, 22353, 22771, 23165, 23548, 23930, 24321, 24726, 25144, 25573, 26010, 26448, 26885, 27319, 27747, 28169, 28589, 29006, 29425, 29844, 30265, 30689, 31115, 31540, 31967, 32391, 32720, 32699, 32022, 30512, 28261, 25670, 23264, 21475, 20513, 20306, 20582, 21002, 21273, 21215, 20779, 20017, 19033, 17953, 16877, 15876, 14989, 14214, 13528, 12894, 12269, 11616, 10914, 10147, 9322, 8452, 7554, 6645, 5743, 4851, 3972, 3103, 2233, 1359, 476, -423, -1337, -2266, -3209, -4160, -5117, -6081, -7044, -7989, -8889, -9715, -10466, -11178, -11898, -12681, -13561, -14537, -15590, -16684, -17758, -18735, -19573, -20297, -21005, -21810, -22702, -23462, -23758, -23339, -22214, -20689, -19223, -18227, -17923, -18286, -19102, -20084, -20973, -21606, -21927, -21969, -21818, -21572, -21320, -21124, -21017, -21007, -21075, -21193, -21326, -21443, -21521, -21549, -21527, -21466, -21377, -21264, -21129, -20974, -20806, -20638, -20484, -20353, -20246, -20155, -20068, -19975, -19863, -19732, -19582, -19416, -19240, -19060, -18879, -18699, -18519, -18336, -18161, -17798, -16884, -15350, -13515, -12061, -11632, -12456, -14242, -16357, -18143, -19159, -19274, -18604, -17401, -15955, -14526, -13324, -12484, -12041, -11950, -12094, -12330, -12520, -12567, -12427, -12112, -11665, -11151, -10634, -10158, -9746, -9406, -9122, -8872, -8632, -8380, -8103, -7796, -7459, -7100, -6727, -6351, -5979, -5619, -5265, -4922, -4582, -4241, -3895, -3544, -3185, -2820, -2452, -2080, -1707, -1334, -962, -590, -210};