/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1124 256 samples */
 
const int16_t AKWF_1124_256_DATA [256] = 
{6367, 10951, 19996, 17042, 15873, 14708, 13750, 12964, 12310, 11769, 11387, 10679, 12984, 14113, 13365, 13085, 12804, 12569, 12378, 12218, 12085, 11976, 11885, 11809, 11747, 11694, 11651, 11614, 11583, 11557, 11536, 11517, 11501, 11487, 11475, 11466, 11457, 11449, 11442, 11435, 11395, 11580, 10647, 8976, 9186, 9143, 9140, 9136, 9133, 9131, 9112, 9197, 8836, 6840, 6853, 6855, 6849, 6817, 6981, 6217, 4429, 4610, 4575, 4573, 4571, 4570, 4569, 4555, 4611, 4390, 2369, 2276, 2304, 2296, 2294, 2293, 2293, 2291, 2270, 2386, 525, -87, 49, 23, 24, 23, 22, 23, 22, 20, 21, 20, 21, -548, 2507, -13883, -35302, -32142, -32728, -32726, -32721, -32717, -32715, -32711, -32670, -32787, -32391, -21014, -19132, -19583, -19492, -19489, -19262, -20448, -10657, -5369, -6488, -6276, -6142, -6875, -3483, 5225, 4534, 4659, 4661, 4673, 4627, 4835, 6690, 7637, 9341, 9156, 9193, 9193, 9191, 9191, 9191, 9189, 9228, 9012, 10647, 11611, 11406, 11442, 11440, 11438, 11435, 11434, 11432, 11430, 11426, 11424, 11422, 11419, 11417, 11414, 11412, 11409, 11407, 11403, 11400, 11398, 11394, 11392, 11389, 11386, 11384, 11381, 11342, 11531, 10606, 8934, 9144, 9102, 9099, 9096, 9093, 9090, 9073, 9158, 8796, 6803, 6814, 6817, 6812, 6780, 6943, 6178, 4391, 4573, 4536, 4536, 4534, 4532, 4530, 4518, 4575, 4347, 2318, 2239, 2266, 2259, 2257, 2255, 2255, 2253, 2231, 2351, 492, -124, 13, -13, -113, 322, -1131, -30033, -33484, -32594, -32762, -32760, -32755, -32753, -32750, -32744, -32740, -32733, -32727, -32722, -32714, -32708, -32703, -32696, -32654, -32768, -32371, -20992, -19109, -19560, -19467, -19462, -19235, -20419, -10628, -5339, -6457, -6246, -6242, -6237, -6234, -6230, -6227, -6223, -6219, -6218, -6202, -6257};