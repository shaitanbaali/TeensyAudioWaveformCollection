/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1157 256 samples */
 
const int16_t AKWF_1157_256_DATA [256] = 
{246, 993, 1747, 2523, 3317, 4132, 4964, 5810, 6670, 7541, 8419, 9302, 10188, 11069, 11948, 12817, 13673, 14515, 15340, 16141, 16920, 17674, 18398, 19093, 19757, 20387, 20986, 21551, 22082, 22582, 23049, 23485, 23893, 24273, 24627, 24959, 25270, 25565, 25845, 26113, 26375, 26633, 26887, 27143, 27404, 27669, 27942, 28223, 28511, 28807, 29110, 29418, 29730, 30042, 30352, 30656, 30953, 31237, 31507, 31758, 31987, 32192, 32370, 32516, 32632, 32713, 32758, 32766, 32736, 32670, 32565, 32421, 32241, 32025, 31775, 31490, 31172, 30825, 30449, 30045, 29618, 29166, 28693, 28200, 27688, 27160, 26618, 26060, 25489, 24907, 24313, 23709, 23097, 22474, 21845, 21209, 20564, 19917, 19263, 18603, 17942, 17278, 16611, 15945, 15277, 14608, 13943, 13279, 12618, 11962, 11309, 10662, 10021, 9384, 8754, 8129, 7508, 6890, 6276, 5658, 5040, 4419, 3789, 3151, 2501, 1837, 1157, 461, -256, -990, -1747, -2524, -3318, -4132, -4964, -5810, -6671, -7542, -8419, -9303, -10188, -11069, -11948, -12817, -13673, -14516, -15340, -16142, -16921, -17674, -18398, -19094, -19757, -20387, -20986, -21551, -22083, -22583, -23049, -23485, -23893, -24273, -24627, -24959, -25271, -25565, -25845, -26114, -26376, -26633, -26887, -27144, -27405, -27669, -27942, -28223, -28512, -28807, -29110, -29418, -29730, -30042, -30352, -30656, -30953, -31237, -31507, -31758, -31987, -32192, -32369, -32516, -32632, -32713, -32758, -32766, -32737, -32669, -32565, -32421, -32241, -32025, -31775, -31490, -31172, -30825, -30448, -30045, -29618, -29166, -28692, -28200, -27688, -27160, -26618, -26060, -25489, -24907, -24313, -23710, -23097, -22474, -21845, -21209, -20565, -19917, -19263, -18604, -17943, -17279, -16612, -15945, -15277, -14609, -13944, -13280, -12619, -11963, -11310, -10662, -10022, -9385, -8754, -8130, -7509, -6891, -6276, -5659, -5041, -4420, -3790, -3152, -2502, -1839, -1161, -451};