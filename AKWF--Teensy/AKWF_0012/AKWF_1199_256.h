/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1199 256 samples */
 
const int16_t AKWF_1199_256_DATA [256] = 
{304, 1175, 2025, 2875, 3722, 4568, 5413, 6255, 7097, 7939, 8775, 9609, 10442, 11266, 12087, 12901, 13705, 14505, 15297, 15977, 17311, 15197, 10964, 12265, 12912, 13651, 14385, 15111, 15828, 16539, 17240, 17932, 18616, 19287, 19949, 20603, 21242, 21873, 22494, 23104, 23580, 24849, 22112, 16518, 17784, 18206, 18748, 19280, 19798, 20308, 20805, 21291, 21765, 22227, 22678, 23119, 23547, 23963, 24370, 24765, 25150, 25565, 25395, 28286, 22447, 14930, 16751, 16790, 17083, 17367, 17641, 17902, 18153, 18393, 18622, 18840, 19049, 19247, 19435, 19612, 19780, 19937, 20086, 20224, 20351, 20470, 20577, 20677, 20766, 20845, 20917, 20978, 21032, 21077, 21115, 21145, 21166, 21180, 21187, 21187, 21179, 21164, 21142, 21114, 21047, 21171, 20475, 14370, 13805, 13881, 13784, 13712, 13637, 13557, 13474, 13388, 13297, 13203, 13107, 13008, 12907, 12803, 12698, 12590, 12481, 12294, 12566, 11049, -5984, -7471, -7270, -10576, -12462, -13143, -13435, -12748, -12844, -13478, -13610, -13538, -13850, -14271, -14348, -14337, -14481, -14559, -14442, -14417, -13813, -16614, -21479, -20870, -20983, -21006, -21043, -21129, -21242, -21337, -21410, -21471, -21498, -21475, -21409, -21313, -21188, -21039, -20884, -20736, -20597, -20475, -20372, -20287, -20214, -20145, -20075, -19990, -19885, -19753, -19591, -19397, -19173, -18924, -18658, -18379, -18094, -17810, -17531, -17257, -16989, -16682, -16947, -14133, -20028, -27571, -25742, -25661, -25289, -24891, -24470, -24032, -23579, -23117, -22651, -22180, -21709, -21236, -20761, -20281, -19793, -19293, -18778, -18377, -17123, -22717, -25448, -24162, -23663, -23029, -22385, -21733, -21077, -20415, -19750, -19081, -18407, -17726, -17037, -16335, -15622, -14895, -14154, -13401, -12668, -11725, -11589, -16847, -16554, -15616, -14840, -14030, -13220, -12408, -11592, -10773, -9946, -9114, -8277, -7431, -6580, -5725, -4863, -4000, -3135, -2271, -1409, -532};