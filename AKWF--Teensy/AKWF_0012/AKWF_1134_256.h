/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1134 256 samples */
 
const int16_t AKWF_1134_256_DATA [256] = 
{10, 38, 67, 96, 128, 161, 197, 233, 273, 315, 356, 400, 447, 495, 543, 595, 647, 700, 755, 810, 914, 736, 2065, 5623, 7379, 8870, 10172, 11343, 12416, 13420, 14363, 15251, 16100, 16908, 17678, 18421, 19127, 19810, 20468, 21099, 21708, 22297, 22861, 23410, 23939, 24450, 24947, 25425, 25888, 26338, 26775, 27199, 27612, 28011, 28401, 28783, 29154, 29519, 29873, 30223, 30567, 30906, 31239, 31570, 31896, 32214, 32572, 32674, 32197, 31693, 31184, 30668, 30145, 29612, 29077, 28535, 27987, 27441, 26889, 26335, 25780, 25223, 24666, 24114, 23558, 22103, 26398, -4516, -30860, -25143, -25190, -24358, -23549, -22765, -22008, -21274, -20565, -19879, -19218, -18579, -17964, -17374, -16805, -16259, -15733, -15229, -14746, -14285, -13841, -13420, -13015, -12628, -12262, -11912, -11579, -11264, -10962, -10677, -10408, -10151, -9910, -9680, -9465, -9261, -9068, -8886, -8716, -8555, -8404, -8261, -8127, -8001, -7884, -7772, -7666, -7566, -7473, -7385, -7301, -7221, -7145, -7072, -7002, -6935, -6870, -6807, -6746, -6685, -6674, -6374, -7627, -11071, -12514, -13625, -14481, -15157, -15696, -16130, -16473, -16741, -16945, -17091, -17185, -17235, -17243, -17216, -17156, -17067, -16949, -16808, -16644, -16461, -16261, -16043, -15810, -15564, -15307, -15038, -14760, -14473, -14178, -13876, -13571, -13259, -12942, -12622, -12298, -11972, -11645, -11315, -10983, -10651, -10316, -9983, -9656, -9280, -8806, -8347, -7903, -7478, -7065, -6668, -6287, -5921, -5572, -5236, -4915, -4608, -4315, -4036, -3771, -3519, -3280, -3052, -2838, -2635, -2444, -2265, -2095, -1936, -1788, -1650, -1519, -1400, -1286, -1184, -1088, -999, -916, -841, -772, -708, -650, -596, -547, -504, -463, -426, -393, -361, -333, -307, -283, -259, -237, -217, -198, -178, -159, -139, -119, -99, -78, -57, -35, -10};