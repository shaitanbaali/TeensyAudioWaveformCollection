/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1149 256 samples */
 
const int16_t AKWF_1149_256_DATA [256] = 
{635, 404, 6737, 9293, 9990, 10720, 11190, 11603, 11533, 10459, 9566, 8827, 8210, 7695, 7259, 6892, 6580, 6311, 6081, 5880, 5702, 5544, 5401, 5272, 5153, 5042, 4938, 4838, 4742, 4651, 4561, 4474, 4386, 4301, 4217, 4132, 4050, 3971, 3892, 3814, 3736, 3658, 3581, 3503, 3425, 3348, 3270, 3192, 3115, 3037, 2959, 2881, 2802, 2723, 2644, 2565, 2487, 2407, 2327, 2248, 2168, 2088, 1980, 2059, 871, 72, 1678, 1997, 2005, 2092, 2167, 2243, 2317, 2391, 2466, 2542, 2617, 2692, 2766, 2841, 2916, 2991, 3066, 3140, 3215, 3289, 3364, 3438, 3513, 3588, 3662, 3882, 3149, 6630, 22454, 22673, 23104, 23562, 23997, 24431, 24866, 25299, 25735, 26169, 26598, 27033, 27464, 27896, 28328, 28761, 29189, 29620, 30051, 30481, 30912, 31340, 31685, 32472, 31709, 7988, 5172, 6017, 5718, 5034, 4365, 3694, 3001, 2482, 729, -194, -1473, -1861, -1873, -1964, -2043, -2122, -2201, -2279, -2356, -2434, -2512, -2589, -2666, -2743, -2820, -2895, -2973, -3048, -3125, -3201, -3277, -3353, -3428, -3504, -3580, -3655, -3731, -3807, -3881, -3957, -4032, -4107, -4182, -4257, -4331, -4407, -4481, -4556, -4632, -4706, -4780, -4854, -4930, -5004, -5078, -5152, -5226, -5301, -5375, -5449, -5524, -5598, -5672, -5744, -5817, -5903, -5499, -4839, -4222, -3594, -2945, -2497, -657, -341, -2188, -2766, -3489, -4198, -4904, -5642, -5867, -5747, -5678, -5600, -5522, -5445, -5367, -5288, -5211, -5133, -5054, -5336, -3285, -20500, -29424, -27057, -26956, -26504, -26055, -25605, -25153, -24701, -24248, -23797, -23346, -22895, -22442, -21989, -21537, -21087, -20636, -20183, -19731, -19278, -18828, -18380, -17926, -17476, -17024, -16572, -16125, -15675, -15223, -14774, -14325, -13876, -13427, -12978, -12527, -12079, -11631, -11184, -10735, -10281, -9866, -9286};