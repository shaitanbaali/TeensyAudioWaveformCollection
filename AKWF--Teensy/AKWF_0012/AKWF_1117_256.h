/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1117 256 samples */
 
const int16_t AKWF_1117_256_DATA [256] = 
{302, 780, 966, 1467, 2358, 3258, 3745, 3846, 4256, 5100, 5951, 6529, 6983, 7476, 7999, 8469, 8929, 9393, 9825, 10259, 10694, 11108, 11519, 11933, 12327, 12722, 13113, 13490, 13865, 14237, 14596, 14950, 15300, 15638, 15973, 16300, 16617, 16929, 17233, 17528, 17815, 18096, 18355, 18839, 19499, 19761, 19661, 19648, 19888, 20160, 20344, 20539, 20750, 20938, 21131, 21325, 21489, 21655, 21818, 21953, 22089, 22215, 22322, 22419, 22509, 22579, 22642, 22692, 22733, 22707, 22423, 22244, 22392, 22622, 22639, 22531, 22451, 22382, 22271, 22148, 22018, 21852, 21689, 21516, 21320, 21119, 20910, 20686, 20437, 19942, 19451, 19299, 19299, 19126, 18793, 18479, 18192, 17873, 17541, 17210, 16854, 16498, 16143, 15772, 15401, 15030, 14648, 14267, 13885, 13498, 13109, 12719, 12325, 11927, 11530, 11124, 10716, 10305, 9885, 9461, 9031, 8594, 8146, 7695, 7232, 6762, 6283, 5795, 5298, 4791, 4276, 3751, 3219, 2678, 2125, 1567, 999, 422, -159, -749, -1347, -1949, -2558, -3173, -3789, -4409, -5020, -5617, -6201, -6769, -7320, -7854, -8367, -8861, -9334, -9787, -10216, -10623, -11010, -11376, -11726, -12054, -12366, -12663, -12942, -13205, -13452, -13684, -13900, -14101, -14286, -14455, -14612, -14755, -14886, -15005, -15153, -15149, -15762, -24208, -32388, -29241, -20368, -16811, -18443, -19449, -19066, -19656, -20458, -20963, -22229, -21859, -19712, -20545, -23941, -25446, -24909, -25516, -27765, -29537, -30337, -31218, -32009, -31933, -31403, -30586, -30300, -30955, -31631, -32117, -32696, -32592, -31592, -30758, -30356, -29032, -27786, -27861, -28355, -28053, -27354, -26746, -26154, -25548, -25242, -24741, -23734, -22598, -21700, -20852, -19620, -18496, -17921, -17911, -17787, -16983, -15518, -14096, -13075, -12279, -11881, -11790, -11345, -9958, -8385, -7305, -6588, -5833, -5048, -4314, -3594, -2919, -2255, -1605, -954, -323};