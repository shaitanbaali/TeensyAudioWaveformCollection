/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1164 256 samples */
 
const int16_t AKWF_1164_256_DATA [256] = 
{596, 1727, 2657, 3672, 4631, 5596, 6569, 10161, 12439, 14331, 16084, 17753, 19231, 20615, 21880, 23027, 24112, 25081, 25993, 26815, 27557, 28243, 28841, 29402, 29892, 30333, 30740, 31088, 31422, 31697, 31952, 32176, 32294, 32427, 32506, 32595, 30938, 29966, 29187, 28412, 27641, 26927, 26227, 25555, 24913, 24286, 23694, 23111, 22561, 22064, 21578, 21116, 20662, 20230, 19811, 19403, 19014, 18634, 18270, 17915, 17572, 17241, 16919, 16607, 16302, 16009, 15722, 15442, 15172, 14907, 14649, 14395, 14149, 13908, 13671, 13439, 13211, 12990, 12771, 12555, 12342, 12133, 11928, 11725, 11525, 11326, 11131, 10939, 10749, 10560, 10371, 10185, 10001, 9818, 9637, 9458, 9278, 9101, 8925, 8748, 8573, 8400, 8225, 8057, 7882, 7710, 7541, 7369, 7202, 7030, 6862, 6694, 6525, 6358, 6187, 6026, 5854, 5687, 5522, 5352, 5193, 5018, 4856, 4690, 4519, 4363, 4184, 4030, 3858, 3687, 3539, 3342, 3201, 3033, 2873, 2, -1640, -2960, -4222, -5446, -6541, -7589, -8562, -9456, -10311, -11086, -11826, -12504, -13134, -13728, -14267, -14782, -15254, -15696, -16112, -16491, -16851, -17179, -17488, -17775, -18042, -18292, -18522, -18740, -18939, -19128, -19304, -19466, -19620, -19762, -19898, -20025, -20141, -20254, -20359, -20458, -20551, -20642, -20728, -20809, -20887, -20959, -21032, -21100, -21166, -21232, -21294, -21356, -21415, -21472, -21529, -21586, -21642, -21696, -21751, -21805, -21859, -21913, -21965, -22020, -22072, -22125, -22180, -22233, -22285, -22336, -22384, -22434, -22482, -22530, -22577, -22623, -22672, -22715, -22764, -22805, -22851, -22898, -22939, -22988, -23028, -23076, -23120, -23160, -23212, -23247, -23299, -23340, -23381, -23440, -23460, -23522, -23567, -23604, -21735, -20605, -19616, -18608, -17575, -16571, -15553, -14544, -13539, -12534, -11533, -10533, -9544, -8549, -7571, -6590, -5617, -4648, -3672, -2726, -1740, -826};