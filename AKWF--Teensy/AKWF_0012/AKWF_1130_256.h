/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1130 256 samples */
 
const int16_t AKWF_1130_256_DATA [256] = 
{1836, 4430, 6423, 8165, 9709, 11074, 12283, 13328, 14224, 14989, 15636, 16183, 16644, 17033, 17362, 17642, 17878, 18079, 18251, 18399, 18527, 18639, 18738, 18825, 18903, 18973, 19039, 19098, 19154, 19207, 19257, 19304, 19349, 19392, 19433, 19473, 19513, 19551, 19590, 19627, 19664, 19701, 19737, 19774, 19810, 19847, 19883, 19920, 19956, 19993, 20029, 20065, 20102, 20139, 20175, 20211, 20249, 20279, 20335, 20736, 20726, 20594, 20537, 20395, 20328, 20277, 20237, 20200, 20164, 20129, 20094, 20059, 20025, 19991, 19957, 19922, 19888, 19854, 19820, 19785, 19751, 19717, 19683, 19649, 19615, 19583, 19287, 20672, 13509, 2655, -1961, -7296, -8989, -9693, -9887, -9859, -9734, -9568, -9383, -9191, -8995, -8799, -8601, -8403, -8206, -8009, -7811, -7614, -7416, -7219, -7025, -6591, -7635, -164, 7686, 11944, 15958, 17470, 18305, 18830, 19235, 19574, 19937, 20518, 20914, 21489, 21723, 21947, 22050, 22118, 22168, 22210, 22248, 22285, 22321, 22357, 22393, 22428, 22463, 22499, 22533, 22568, 22604, 22639, 22674, 22709, 22744, 22778, 22813, 22848, 22882, 22917, 22951, 22986, 23021, 23054, 23089, 23124, 23158, 23192, 23226, 23260, 23295, 23330, 23363, 23398, 23432, 23466, 23500, 23534, 23569, 23602, 23636, 23671, 23705, 23738, 23772, 23806, 23839, 23879, 23885, 23761, 23587, 23347, 23079, 22811, 22504, 21883, 21962, 22022, 22280, 22597, 22915, 23243, 23545, 23701, 23795, 23817, 23807, 23782, 23751, 23717, 23683, 23647, 23612, 23594, 23287, 24482, -1445, -11002, -23568, -29188, -31534, -32457, -32742, -32749, -32635, -32469, -32280, -32081, -31878, -31672, -31466, -31258, -31052, -30845, -30638, -30431, -30223, -30017, -29811, -29604, -29397, -29189, -28983, -28777, -28571, -28365, -28159, -27953, -27747, -27541, -27336, -27130, -26923, -26718, -26513, -26307, -26051, -26077, -24728, -20616, -15739, -10099, -5349, -1243};