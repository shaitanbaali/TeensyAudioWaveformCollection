/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1133 256 samples */
 
const int16_t AKWF_1133_256_DATA [256] = 
{75, 371, 796, 1323, 1574, 1550, 1442, 1330, 1305, 1453, 1820, 2421, 3215, 4120, 5016, 5780, 6283, 6439, 6209, 5621, 4734, 4380, 4660, 5054, 5547, 6070, 6574, 7003, 7316, 7480, 7476, 7302, 6974, 6524, 5992, 5435, 4916, 4496, 4235, 4180, 4366, 4810, 5502, 6422, 7530, 8740, 9237, 9097, 8783, 8410, 8105, 7972, 8088, 8494, 9197, 10160, 11312, 12545, 13755, 14810, 15602, 16042, 16081, 15708, 14959, 13926, 12626, 12461, 13578, 14715, 15979, 17181, 18193, 18908, 19227, 19103, 18505, 17464, 16020, 14279, 12360, 10400, 8632, 7218, 6262, 5872, 6110, 6997, 8512, 10579, 13057, 15993, 17403, 16253, 14448, 12600, 11217, 10684, 11239, 12953, 15706, 19212, 23075, 26811, 29934, 32030, 32773, 32038, 29857, 26545, 22107, 19890, 21714, 24231, 26953, 29293, 30831, 31239, 30347, 28097, 26053, -14003, -20067, -13410, -10404, -8083, -7163, -7728, -9723, -12918, -17025, -21433, -22053, -19883, -17335, -15120, -13883, -13979, -15484, -18179, -21644, -25261, -28435, -30584, -31303, -30418, -28014, -24425, -20026, -17906, -18105, -18639, -19415, -20210, -20861, -21242, -21269, -20897, -20129, -19000, -17589, -15990, -14323, -12709, -11271, -10110, -9310, -8922, -8966, -9425, -10253, -11367, -12690, -14060, -14333, -13704, -12878, -12017, -11279, -10787, -10606, -10757, -11211, -11905, -12735, -13593, -14358, -14919, -15192, -15127, -14709, -13961, -12942, -11757, -10430, -9996, -10489, -10945, -11444, -11858, -12116, -12161, -11962, -11509, -10818, -9924, -8874, -7736, -6582, -5480, -4527, -3786, -3278, -3021, -3013, -3234, -3648, -4204, -4838, -5546, -5736, -5180, -4487, -3832, -3337, -3074, -3063, -3279, -3661, -4123, -4575, -4927, -5114, -5094, -4862, -4438, -3877, -3242, -2577, -2178, -2129, -2091, -2025, -1898, -1702, -1449, -1165, -881, -628, -428, -295, -227, -207, -205, -184, -95};