/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1166 256 samples */
 
const int16_t AKWF_1166_256_DATA [256] = 
{184, 727, 1283, 1793, 2273, 2849, 3208, 3529, 3794, 3852, 3985, 3980, 3836, 3814, 3745, 3705, 3472, 3292, 2951, 2622, 2761, 2373, 1948, 1833, 1461, 1151, 1268, 865, 704, 748, 529, 474, 398, 371, 481, 291, 201, 263, 151, 196, 271, 376, 420, 601, 625, 745, 939, 1155, 1442, 1528, 1725, 2018, 2374, 2509, 2642, 2912, 3016, 3228, 4736, 4088, 4127, 4678, 5009, 5150, 5431, 5708, 6033, 5952, 6043, 6352, 6373, 6398, 6570, 6728, 6511, 6528, 6523, 6504, 6515, 6431, 6371, 6408, 6213, 5966, 6149, 5735, 5568, 5823, 5599, 5272, 5492, 5240, 5021, 4990, 5036, 4951, 4613, 4639, 4806, 4544, 4596, 4727, 4637, 4776, 4608, 4368, 4493, 4599, 4386, 4301, 4184, 4028, 3988, 3858, 3902, 3672, 3685, 3845, 3597, 8252, 10702, 13661, 18034, 17854, 20650, 23796, 25877, 27771, 29428, 30612, 31617, 32311, 32624, 32758, 32601, 32145, 31399, 30401, 29298, 28150, 26692, 25143, 23539, 21790, 19864, 17896, 15844, 13810, 12040, 9970, 8100, 6277, 4189, 2381, 962, -720, -2323, -3660, -5136, -6349, -7714, -8919, -9726, -10828, -11908, -12802, -13537, -14153, -14910, -15525, -16082, -16444, -16825, -17210, -17564, -17646, -17655, -17768, -17765, -17908, -17656, -17503, -17498, -17355, -17305, -17120, -15857, -16229, -16173, -15837, -15431, -14976, -14829, -14760, -14359, -14146, -14059, -13808, -13564, -13405, -13206, -12954, -12892, -12810, -12696, -12489, -12443, -12406, -12273, -12221, -12205, -12154, -11962, -12131, -12044, -11782, -12038, -12083, -11703, -11737, -11737, -11586, -11515, -11344, -11352, -11195, -10932, -10990, -10868, -10645, -10461, -10238, -10318, -10300, -10070, -9901, -9789, -9549, -9377, -9265, -9039, -8969, -8705, -8562, -8352, -8075, -7928, -7631, -7567, -5123, -3662, -4451, -3414, -2200, -1422, -568};