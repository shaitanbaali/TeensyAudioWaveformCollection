/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1172 256 samples */
 
const int16_t AKWF_1172_256_DATA [256] = 
{46, 199, 344, 493, 635, 1009, 1725, 2589, 3518, 4476, 5440, 6398, 7343, 8263, 9160, 10028, 10866, 11676, 12456, 13204, 13927, 14623, 15290, 15934, 16552, 17145, 17715, 18261, 18783, 19284, 19760, 20215, 20604, 21176, 20779, 15578, 11860, 10642, 10194, 10141, 10312, 10621, 11010, 11438, 11877, 12301, 12698, 13066, 13433, 13372, 18750, 26870, 30296, 31824, 32534, 32763, 32675, 32368, 31912, 31360, 30752, 30113, 29463, 28818, 28183, 27567, 26967, 26384, 25820, 25272, 24735, 24209, 23692, 23179, 22669, 22161, 21652, 21143, 20629, 20112, 19593, 19067, 18536, 18001, 17461, 16917, 16370, 15817, 15262, 14705, 14145, 13583, 13020, 12456, 11894, 11332, 10754, 10105, 10160, -9, -12792, -18092, -20814, -22359, -23229, -23665, -23811, -23776, -23638, -23448, -23249, -23068, -22921, -22819, -22768, -22766, -22812, -22903, -23033, -23197, -23389, -23604, -23837, -24083, -24336, -24595, -24855, -25113, -25368, -25617, -25857, -26089, -26311, -26520, -26719, -26905, -27078, -27238, -27385, -27519, -27640, -27747, -27841, -27923, -27991, -28045, -28088, -28118, -28136, -28142, -28134, -28117, -28088, -28047, -27994, -27824, -28263, -24912, -16101, -11883, -10070, -9130, -8673, -8514, -8547, -8700, -8920, -9165, -9411, -9638, -9833, -9988, -10100, -10167, -10191, -10173, -10117, -10026, -9903, -9799, -9439, -9988, -15602, -19340, -20560, -21021, -21070, -20866, -20497, -20019, -19475, -18897, -18302, -17712, -17135, -16576, -16043, -15535, -15051, -14594, -14160, -13746, -13352, -12975, -12613, -12263, -11926, -11597, -11276, -10962, -10655, -10351, -10053, -9758, -9466, -9178, -8892, -8610, -8329, -8051, -7776, -7503, -7233, -6965, -6700, -6437, -6178, -5922, -5668, -5417, -5168, -4924, -4682, -4443, -4209, -3978, -3749, -3524, -3303, -3085, -2871, -2660, -2453, -2250, -2051, -1854, -1662, -1474, -1289, -1108, -931, -759, -589, -423, -263, -103};