/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1135 256 samples */
 
const int16_t AKWF_1135_256_DATA [256] = 
{4, 264, 444, 771, 1024, 1150, 1334, 1472, 1509, 1581, 1946, 2079, 2131, 2307, 2048, 2066, 1944, 1844, 1957, 2417, 2436, 3018, 3386, 4055, 4345, 4904, 5162, 5554, 6122, 6350, 5749, 5902, 5788, 5748, 5839, 6129, 5337, 4618, 4000, 2784, 2047, 2965, 3828, 5012, 7829, 10043, 12060, 13153, 14458, 16331, 15647, 15585, 15682, 15159, 14609, 13789, 12528, 11096, 9135, 8314, 6347, 7129, 7926, 8896, 9051, 10852, 12434, 14575, 18051, 19543, 20816, 21454, 23032, 22856, 23598, 20999, 19689, 17702, 16401, 16329, 14487, 15204, 14371, 15504, 14556, 15413, 13878, 14277, 16488, 16920, 20045, 22816, 23645, 27296, 27648, 29676, 31664, 31916, 29483, 30403, 30402, 30348, 29821, 29920, 29851, 27746, 26022, 24118, 24184, 24491, 25393, 23537, 23932, 24998, 24693, 24264, 23789, 24697, 24358, 24646, 23648, 23152, 25321, 9444, -26588, -24029, -23124, -22552, -22476, -24237, -23995, -25898, -26463, -25095, -24699, -23874, -22251, -21100, -22448, -21908, -20725, -20622, -17838, -16952, -15434, -14152, -13926, -15302, -14684, -16367, -17071, -18780, -18980, -20105, -20088, -20476, -21352, -21183, -18756, -18492, -17535, -16839, -16457, -16554, -14286, -12324, -10681, -7989, -6392, -7879, -9142, -10886, -15150, -18204, -20728, -21721, -22921, -24825, -23166, -22377, -21845, -20537, -19262, -17767, -15861, -13838, -11401, -10231, -8024, -8544, -9055, -9658, -9533, -10768, -11759, -13119, -15379, -16030, -16464, -16410, -16979, -16348, -16299, -14232, -13008, -11491, -10406, -10047, -8789, -8884, -8193, -8465, -7761, -7884, -6988, -6914, -7528, -7446, -8273, -8931, -8858, -9652, -9389, -9584, -9743, -9386, -8388, -8235, -7865, -7487, -7031, -6700, -6347, -5653, -5085, -4518, -4268, -4055, -3904, -3450, -3255, -3111, -2849, -2586, -2327, -2161, -1919, -1717, -1469, -1273, -1053, -866, -686, -494, -332, -179};