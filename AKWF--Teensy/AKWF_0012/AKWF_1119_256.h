/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1119 256 samples */
 
const int16_t AKWF_1119_256_DATA [256] = 
{155, 412, 638, 950, 1356, 1779, 2150, 2451, 2721, 3002, 3321, 3668, 4016, 4338, 4625, 4896, 5174, 5477, 5816, 6199, 6626, 7089, 7600, 8186, 8871, 9671, 10602, 11669, 12878, 14229, 15704, 17264, 18866, 20457, 21989, 23410, 24715, 25918, 26943, 27666, 28063, 28222, 28318, 28569, 29083, 29723, 30222, 30442, 30485, 30572, 30844, 31270, 31709, 32040, 32259, 32423, 32571, 32693, 32758, 32762, 32709, 32595, 32399, 32112, 31775, 31474, 31245, 31033, 30746, 30329, 29817, 29309, 28828, 28250, 27423, 26353, 25203, 24145, 23191, 22223, 21127, 19873, 18520, 17157, 15875, 14744, 13754, 12817, 11882, 11231, 11385, 12186, 12639, 12030, 10746, 9712, 9391, 9548, 9659, 9386, 8799, 8177, 7616, 7060, 6551, 6166, 5817, 5362, 4838, 4418, 4189, 4078, 3970, 3780, 3480, 3102, 2700, 2350, 2099, 1914, 1745, 1557, 1318, 1017, 690, 364, 10, -370, -721, -1005, -1267, -1567, -1915, -2282, -2626, -2931, -3238, -3600, -4021, -4460, -4885, -5304, -5729, -6124, -6449, -6717, -7003, -7375, -7825, -8278, -8655, -8924, -9119, -9337, -9663, -10084, -10505, -10845, -11106, -11347, -11617, -11919, -12223, -12503, -12753, -12995, -13240, -13482, -13695, -13867, -14009, -14656, -17247, -22053, -26689, -28442, -27471, -26355, -27047, -29318, -31603, -32554, -32046, -31018, -30276, -29962, -30056, -30482, -30757, -30355, -29445, -28758, -28766, -29278, -29818, -30053, -29909, -29445, -28782, -28148, -27766, -27633, -27587, -27507, -27292, -26873, -26323, -25782, -25189, -24450, -23714, -23157, -22705, -22181, -21517, -20791, -20173, -19780, -19541, -19237, -18715, -17990, -17169, -16321, -15487, -14756, -14233, -13910, -13591, -13040, -12236, -11378, -10689, -10296, -10175, -10104, -9760, -9015, -8102, -7372, -6967, -6716, -6357, -5759, -5003, -4286, -3734, -3333, -2972, -2549, -2078, -1667, -1352, -1039, -640, -196};