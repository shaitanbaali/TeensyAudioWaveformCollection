/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1200 256 samples */
 
const int16_t AKWF_1200_256_DATA [256] = 
{1506, 3079, 4998, 6767, 8254, 9149, 11326, 12422, 13638, 15605, 16345, 17031, 18978, 19749, 20517, 21429, 21990, 22587, 23167, 23735, 24299, 24851, 25380, 27185, 28026, 28449, 29107, 28617, 28378, 29017, 29364, 29469, 29918, 30432, 29664, 29626, 30126, 30496, 30910, 30971, 31026, 32074, 24162, 20448, 21191, 21181, 20226, 19840, 19701, 18543, 18675, 17792, 17459, 17659, 17592, 17014, 16201, 16482, 16591, 16713, 16823, 17161, 15958, 22921, 32305, 31943, 31066, 31106, 31111, 31097, 31101, 30948, 30528, 30601, 29451, 28706, 28450, 27806, 26542, 26214, 25855, 24507, 23902, 23409, 23339, 22180, 21206, 21081, 20446, 20142, 20029, 18768, 17776, 17579, 16861, 16670, 15551, 14315, 14129, 13767, 13425, 13074, 12719, 12337, 12020, 12939, 12757, 12315, 11925, 11521, 11115, 10672, 10391, 10307, 9855, 9439, 8936, 8798, 9589, 9373, 9113, 9749, 10325, 11147, 11707, 12066, 14827, 4333, -9393, -6443, -7547, -10655, -11157, -12173, -10550, -9942, -10185, -9790, -9939, -10293, -9821, -10329, -10495, -10585, -11134, -11444, -11605, -11838, -12116, -12324, -12543, -11581, -11629, -12085, -12338, -13787, -14979, -15257, -15797, -16548, -16891, -17101, -18540, -19202, -19280, -19460, -19582, -20054, -20436, -20509, -21179, -22591, -23040, -23493, -24983, -25873, -26473, -28048, -28283, -29482, -30088, -30119, -30389, -31143, -32116, -31987, -32022, -32037, -32059, -31839, -33146, -26261, -16929, -17305, -18156, -18049, -17934, -17799, -17609, -17544, -17721, -17382, -18250, -18696, -18642, -18962, -19888, -19855, -19833, -20773, -21008, -20671, -21706, -30767, -31266, -30738, -30763, -30415, -29855, -30427, -30713, -30190, -30176, -29620, -29974, -30429, -29817, -29354, -28852, -28335, -27794, -27264, -26645, -24767, -23979, -23435, -22828, -22226, -21616, -21036, -20290, -19336, -18741, -18103, -17540, -16601, -14723, -13840, -12992, -11243, -9543, -7593, -5908, -4037, -2203, -527};