/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1169 256 samples */
 
const int16_t AKWF_1169_256_DATA [256] = 
{163, 781, 1706, 2939, 4468, 6255, 8288, 10507, 12933, 15508, 18181, 21099, 23532, 23587, 22329, 20564, 18033, 14802, 11437, 8367, 5812, 3888, 2566, 1665, 1058, 655, 391, 218, 110, 43, 4, -16, -27, -31, -33, -13, 145, 561, 1284, 2319, 3670, 5305, 7192, 9317, 11623, 14102, 16734, 19500, 22352, 25300, 28298, 31378, 32840, 30510, 25185, 18426, 11142, 4759, 874, -1270, -2362, -2800, -2850, -2682, -2409, -2094, -1782, -1490, -1228, -1002, -825, -596, -775, -2127, -2428, -1768, -474, 1292, 3421, 5806, 8386, 11121, 13956, 16897, 19916, 22998, 26107, 29303, 32311, 32307, 28506, 22399, 15312, 8201, 1442, -4036, -6848, -7892, -7937, -7420, -6634, -5753, -4880, -4070, -3354, -2733, -2211, -1782, -1380, -2320, -4803, -7733, -10609, -13124, -15114, -16520, -17315, -17713, -16577, -12573, -7106, -1009, 5303, 11475, 17521, 21728, 21885, 18558, 13292, 7281, 1269, -4264, -7607, -8822, -8908, -8347, -7477, -6490, -5510, -4599, -3788, -3090, -2498, -2023, -1538, -1747, -3801, -6634, -9604, -12314, -14546, -16224, -17308, -17819, -17804, -17310, -16391, -15093, -13486, -11602, -9454, -7219, -5536, -5404, -7060, -9704, -12716, -15824, -17748, -17549, -16253, -14442, -12467, -10547, -8785, -7215, -5871, -4735, -3790, -3030, -2387, -1952, -3230, -5824, -8757, -11559, -13996, -15895, -17217, -17966, -18168, -17872, -17131, -15996, -14518, -12744, -10732, -8478, -6375, -5174, -4796, -4818, -4920, -4894, -4635, -4183, -3650, -3114, -2607, -2153, -1758, -1422, -1142, -914, -725, -572, -449, -354, -236, 43, 584, 1432, 2564, 4116, 4479, 2974, 860, -1285, -3100, -4437, -5209, -5409, -5078, -4265, -3059, -2183, -2133, -2568, -3129, -3564, -3740, -3580, -3226, -2817, -2404, -2013, -1662, -1358, -1098, -883, -705, -560, -442, -348, -269, -93};