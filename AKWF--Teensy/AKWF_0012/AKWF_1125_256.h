/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1125 256 samples */
 
const int16_t AKWF_1125_256_DATA [256] = 
{1240, 1193, 1201, 1200, 1200, 1199, 1200, 1200, 1200, 1200, 1221, 1098, 1636, 3350, 3234, 3254, 3253, 3253, 3253, 3253, 3296, 3094, 3855, 14290, 15468, 15160, 15221, 15218, 15371, 14508, 18786, 27873, 27030, 27175, 27171, 27169, 27164, 27160, 27154, 27149, 27144, 27139, 27133, 27127, 27122, 26912, 28008, 19214, 14268, 15309, 15111, 15104, 15098, 15094, 15086, 15083, 15081, 14897, 15861, 6557, 2322, 3250, 3077, 3074, 3071, 3068, 3064, 3063, 3062, 3058, 3056, 2932, 3619, 614, -9452, -8822, -8928, -8929, -8930, -8928, -8930, -8962, -8817, -9270, -19996, -21160, -20835, -20894, -20893, -20889, -20885, -20882, -20881, -20877, -20873, -20868, -20864, -20860, -20855, -20852, -20847, -20841, -20836, -20833, -20827, -20821, -20817, -20812, -20804, -20989, -19860, -28727, -24056, -20047, -20893, -20770, -20764, -20758, -20753, -20747, -20741, -20735, -20730, -20725, -20720, -20664, -20912, -19977, -9228, -8556, -8757, -8710, -8706, -8701, -8696, -8691, -8689, -8685, -8555, -9269, -6129, 3865, 3190, 3308, 3309, 3311, 3311, 3313, 3325, 3286, 3444, 5221, 5412, 5362, 5373, 5372, 5399, 5251, 6010, 7544, 7399, 7423, 7423, 7422, 7421, 7420, 7418, 7417, 7416, 7415, 7413, 7411, 7410, 7373, 7563, 6056, 5202, 5380, 5346, 5344, 5342, 5341, 5339, 5338, 5337, 5304, 5471, 3876, 3144, 3303, 3274, 3272, 3270, 3269, 3268, 3267, 3266, 3264, 3264, 3241, 3359, 2847, 1115, 1222, 1203, 1202, 1201, 1201, 1200, 1194, 1218, 1139, -700, -901, -847, -857, -857, -858, -857, -858, -859, -858, -858, -858, -858, -858, -858, -858, -859, -858, -858, -858, -857, -858, -857, -857, -857, -890, -695, -2215, -1419, -730, -876, -856, -855, -855, -855, -856, -855, -854, -855, -854, -854, -855, -852, -866};