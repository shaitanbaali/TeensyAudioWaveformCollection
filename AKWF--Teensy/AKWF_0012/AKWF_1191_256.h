/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1191 256 samples */
 
const int16_t AKWF_1191_256_DATA [256] = 
{717, 2099, 3503, 4998, 6543, 8078, 9588, 11076, 12556, 14018, 15465, 16900, 18289, 19603, 20854, 22043, 23152, 24189, 25190, 26204, 27219, 28185, 29076, 29878, 30574, 31157, 31646, 32064, 32386, 32606, 32736, 32766, 32684, 32500, 32242, 31938, 31562, 31080, 30490, 29802, 29008, 28110, 27143, 26112, 24998, 23788, 22496, 21136, 19715, 18239, 16764, 15356, 14006, 12690, 11400, 10124, 8865, 7617, 6393, 5211, 4031, 2839, 1667, 505, -664, -1841, -2992, -4060, -5065, -6060, -7056, -8031, -8973, -9889, -10757, -11581, -12387, -13186, -13966, -14713, -15425, -16100, -16709, -17207, -17609, -17949, -18245, -18507, -18739, -18940, -19094, -19189, -19265, -19335, -19383, -19416, -19446, -19461, -19434, -19342, -19212, -19083, -18958, -18834, -18720, -18617, -18496, -18351, -18207, -18084, -17964, -17838, -17711, -17569, -17365, -17042, -16601, -16076, -15482, -14819, -14099, -13325, -12476, -11552, -10591, -9602, -8572, -7511, -6436, -5361, -4254, -3076, -1865, -681, 461, 1571, 2659, 3721, 4760, 5781, 6752, 7648, 8481, 9254, 9954, 10588, 11195, 11828, 12474, 13087, 13643, 14127, 14528, 14838, 15076, 15270, 15393, 15439, 15422, 15332, 15155, 14904, 14607, 14289, 13925, 13481, 12957, 12363, 11690, 10944, 10159, 9345, 8483, 7563, 6602, 5616, 4601, 3558, 2535, 1597, 733, -83, -863, -1614, -2339, -3042, -3707, -4321, -4921, -5516, -6082, -6621, -7153, -7676, -8159, -8557, -8902, -9249, -9612, -9971, -10317, -10657, -10976, -11276, -11581, -11907, -12241, -12566, -12883, -13190, -13458, -13640, -13752, -13830, -13890, -13941, -13986, -14028, -14045, -14024, -14010, -14007, -14001, -14000, -14010, -14022, -14002, -13927, -13824, -13729, -13642, -13562, -13493, -13433, -13355, -13247, -13133, -13031, -12926, -12808, -12675, -12517, -12284, -11916, -11416, -10817, -10132, -9365, -8524, -7610, -6609, -5512, -4361, -3166, -1914, -583};