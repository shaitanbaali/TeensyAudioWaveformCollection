/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1185 256 samples */
 
const int16_t AKWF_1185_256_DATA [256] = 
{566, 1803, 2979, 4120, 5225, 6292, 7322, 8310, 9261, 10174, 11046, 11881, 12680, 13438, 14161, 14848, 15498, 16114, 16696, 17242, 17756, 18239, 18689, 19109, 19500, 19860, 20192, 20496, 20773, 21025, 21250, 21451, 21628, 21781, 21911, 22020, 22108, 22175, 22222, 22251, 22259, 22251, 22225, 22183, 22125, 22051, 21964, 21861, 21745, 21617, 21477, 21325, 21162, 20989, 20807, 20615, 20415, 20207, 19991, 19769, 19541, 19307, 19068, 18825, 18577, 18326, 18073, 17816, 17559, 17299, 17039, 16779, 16519, 16258, 16000, 15743, 15487, 15235, 14984, 14736, 14493, 14253, 14018, 13786, 13559, 13338, 13122, 12911, 12707, 12509, 12316, 12130, 11951, 11779, 11613, 11455, 11303, 11159, 11022, 10892, 10769, 10654, 10546, 10446, 10353, 10266, 10186, 10113, 10047, 9989, 9935, 9888, 9848, 9814, 9784, 9761, 9743, 9729, 9720, 9716, 9717, 9720, 9728, 9738, 9752, 9768, 9786, 9807, 9829, 9852, 9877, 9902, 9927, 9952, 9978, 10002, 10025, 10047, 10068, 10085, 10102, 10115, 10126, 10134, 10138, 10139, 10136, 10128, 10117, 10101, 10080, 10054, 10024, 9987, 9946, 9899, 9845, 9787, 9723, 9653, 9576, 9494, 9407, 9312, 9213, 9107, 8995, 8878, 8755, 8626, 8492, 8352, 8208, 8058, 7902, 7743, 7580, 7412, 7239, 7064, 6884, 6701, 6516, 6328, 6136, 5943, 5748, 5552, 5354, 5155, 4956, 4751, 4574, 4183, 3760, 3171, 2418, 1552, 502, -671, -1979, -3410, -4953, -6601, -8329, -10109, -11928, -13760, -15579, -17375, -19124, -20806, -22415, -23931, -25341, -26643, -27823, -28877, -29808, -30607, -31277, -31822, -32241, -32536, -32710, -32767, -32710, -32539, -32258, -31869, -31374, -30776, -30078, -29282, -28397, -27423, -26369, -25246, -24053, -22801, -21504, -20160, -18781, -17380, -15954, -14517, -13077, -11634, -10197, -8774, -7362, -5972, -4606, -3264, -1954, -651};