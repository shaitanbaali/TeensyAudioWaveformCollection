/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1101 256 samples */
 
const int16_t AKWF_1101_256_DATA [256] = 
{43, 164, 283, 403, 522, 641, 761, 881, 1000, 1121, 1241, 1362, 1484, 1606, 1729, 1853, 1977, 2102, 2228, 2355, 2484, 2613, 2744, 2877, 3011, 3146, 3284, 3423, 3564, 3707, 3853, 4001, 4151, 4305, 4460, 4620, 4781, 4946, 5116, 5289, 5465, 5645, 5830, 6020, 6214, 6413, 6618, 6829, 7045, 7267, 7497, 7734, 7979, 8230, 8490, 8760, 9038, 9320, 9598, 9863, 10113, 10349, 10571, 10780, 10978, 11161, 11327, 11475, 11603, 11714, 11806, 11882, 11943, 11987, 12018, 12034, 12039, 12035, 12026, 12012, 11993, 11970, 11943, 11913, 11878, 11840, 11801, 11756, 11710, 11661, 11609, 11555, 11497, 11439, 11379, 11316, 11252, 11186, 11119, 11050, 10980, 10909, 10836, 10763, 10688, 10613, 10537, 10460, 10383, 10304, 10225, 10146, 10067, 9986, 9906, 9826, 9745, 9665, 9583, 9502, 9421, 9340, 9258, 9177, 9097, 9016, 8935, 8854, 8775, 8695, 8614, 8535, 8456, 8377, 8299, 8221, 8142, 8064, 7987, 7911, 7835, 7759, 7683, 7609, 7535, 7450, 7257, 7795, 56, -14678, -21901, -23800, -23942, -23624, -23128, -22849, -26817, -31293, -32695, -32642, -32151, -31552, -30936, -30324, -29712, -29131, -28541, -24904, -20396, -18253, -17362, -16860, -16467, -16109, -15760, -15420, -15085, -14757, -14434, -14117, -13806, -13500, -13200, -12904, -12614, -12329, -12049, -11773, -11503, -11236, -10975, -10719, -10465, -10217, -9974, -9733, -9497, -9264, -9035, -8811, -8590, -8372, -8158, -7948, -7740, -7536, -7335, -7137, -6944, -6751, -6562, -6376, -6193, -6013, -5835, -5660, -5487, -5317, -5148, -4983, -4819, -4658, -4499, -4342, -4187, -4033, -3882, -3733, -3586, -3440, -3295, -3153, -3012, -2872, -2734, -2597, -2462, -2328, -2195, -2064, -1933, -1804, -1675, -1548, -1421, -1295, -1171, -1046, -923, -801, -678, -557, -435, -315, -196, -73};