/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1180 256 samples */
 
const int16_t AKWF_1180_256_DATA [256] = 
{23973, 27338, 28521, 29914, 30918, 31667, 32188, 32575, 32733, 32764, 32683, 32516, 32285, 32006, 31697, 31370, 31039, 30709, 30391, 30092, 29811, 29556, 29327, 29124, 28950, 28803, 28681, 28584, 28510, 28457, 28423, 28407, 28403, 28414, 28435, 28465, 28502, 28543, 28588, 28635, 28683, 28730, 28776, 28818, 28856, 28891, 28920, 28943, 28962, 28973, 28976, 28973, 28962, 28944, 28918, 28884, 28841, 28791, 28732, 28665, 28591, 28507, 28415, 28316, 28208, 28092, 27967, 27835, 27695, 27546, 27389, 27225, 27053, 26873, 26686, 26490, 26288, 26079, 25860, 25635, 25405, 25166, 24919, 24668, 24408, 24142, 23870, 23590, 23305, 23014, 22717, 22413, 22104, 21789, 21468, 21141, 20809, 20474, 20133, 19786, 19434, 19079, 18719, 18355, 17985, 17613, 17237, 16857, 16473, 16087, 15697, 15303, 14908, 14509, 14108, 13705, 13301, 12893, 12484, 12074, 11661, 11244, 10838, 10419, 10003, 9456, 9734, 6457, -14456, -15916, -17701, -19226, -20418, -21353, -22062, -22608, -22956, -23174, -23280, -23302, -23258, -23168, -23046, -22906, -22761, -22620, -22488, -22374, -22281, -22211, -22167, -22151, -22162, -22199, -22261, -22348, -22457, -22588, -22737, -22902, -23082, -23275, -23478, -23688, -23906, -24128, -24353, -24580, -24807, -25033, -25256, -25477, -25694, -25907, -26113, -26315, -26508, -26696, -26876, -27048, -27213, -27370, -27518, -27658, -27789, -27913, -28028, -28134, -28231, -28321, -28401, -28472, -28535, -28591, -28637, -28675, -28705, -28726, -28739, -28744, -28740, -28729, -28710, -28682, -28646, -28604, -28554, -28495, -28430, -28356, -28276, -28188, -28094, -27991, -27883, -27769, -27646, -27518, -27383, -27241, -27095, -26941, -26782, -26616, -26446, -26270, -26089, -25902, -25710, -25513, -25311, -25106, -24895, -24681, -24461, -24238, -24011, -23781, -23547, -23310, -23070, -22827, -22580, -22331, -22080, -21826, -21572, -21315, -21054, -20786, -20539, -20267, -20002, -19591, -20158, -15996};