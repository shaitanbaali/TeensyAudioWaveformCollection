/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1163 256 samples */
 
const int16_t AKWF_1163_256_DATA [256] = 
{1536, 4093, 10699, 14429, 17591, 20302, 22600, 24553, 26204, 27576, 28718, 29668, 30448, 31078, 31580, 31972, 32267, 32483, 32630, 32718, 32756, 32672, 32522, 32351, 32156, 31946, 31721, 31489, 31249, 31004, 30758, 30508, 30189, 30331, 25127, 20452, 17956, 15450, 13308, 11456, 9858, 8491, 7325, 6323, 5467, 4743, 4133, 3621, 3197, 2848, 2562, 2332, 2148, 2005, 1897, 1818, 1762, 1726, 1707, 1702, 1709, 1724, 1741, 1741, 1953, -2135, -5362, -7186, -8969, -10486, -11796, -12917, -13876, -14691, -15379, -15957, -16439, -16835, -17160, -17422, -17630, -17791, -17914, -18003, -18064, -18101, -18118, -18118, -18105, -18082, -18049, -18008, -17963, -17913, -17861, -17808, -17752, -17697, -17640, -17585, -17531, -17478, -17425, -17376, -17326, -17279, -17232, -17189, -17148, -17107, -17068, -17031, -16996, -16961, -16929, -16898, -16867, -16839, -16811, -16737, -16923, -16022, -8220, -4182, -1047, 1795, 4229, 6429, 7854, 8145, 10647, 11993, 13313, 15063, 16264, 17228, 18284, 20207, 21392, 22379, 23221, 23922, 24506, 24986, 25379, 25692, 25931, 26107, 26231, 26312, 26355, 26367, 26354, 26319, 26266, 26200, 26123, 26036, 25944, 25848, 25747, 25645, 25539, 25490, 25265, 22021, 20038, 18646, 17350, 16231, 15265, 14429, 13708, 13092, 12565, 12117, 11739, 11420, 11155, 10890, 10942, 9592, 6266, 4796, 3376, 2174, 1139, 235, -436, -1373, -5991, -8747, -10823, -12688, -14285, -15655, -16821, -17811, -18648, -19349, -19931, -20413, -20807, -21124, -21378, -21574, -21725, -21835, -21913, -21962, -21988, -21995, -21987, -21965, -21934, -21896, -21851, -21802, -21752, -21699, -21645, -21592, -21539, -21488, -21442, -21390, -21340, -22651, -23544, -24096, -24621, -25066, -25449, -25777, -26054, -26278, -26460, -26606, -26717, -26808, -26925, -26722, -26371, -26142, -25876, -25608, -25339, -25067, -24756, -24645, -23819, -14950, -9735, -6774, -4807, -2270};