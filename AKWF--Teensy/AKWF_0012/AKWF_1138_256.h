/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1138 256 samples */
 
const int16_t AKWF_1138_256_DATA [256] = 
{851, 2032, 3096, 4072, 4967, 5789, 6543, 7235, 7874, 8465, 9010, 9516, 9985, 10421, 10826, 11205, 11556, 11884, 12190, 12474, 12738, 12985, 13214, 13423, 13616, 13794, 13956, 14103, 14235, 14351, 14453, 14541, 14614, 14673, 14719, 14764, 14711, 15130, 14848, 14737, 14839, 14877, 14914, 14946, 14976, 15004, 15029, 15051, 15074, 15095, 15114, 15133, 15150, 15167, 15185, 15199, 15214, 15229, 15242, 15255, 15269, 15280, 15292, 15303, 15314, 15324, 15335, 15344, 15353, 15362, 15371, 15379, 15386, 15393, 15401, 15408, 15414, 15420, 15426, 15432, 15436, 15309, 15851, 14163, -28207, -33827, -32411, -32689, -32695, -32701, -32705, -32709, -32712, -32714, -32715, -32716, -32716, -32715, -32713, -32710, -32709, -32705, -32701, -32697, -32693, -32689, -32674, -32222, -34849, 4509, 18164, 15145, 15688, 15691, 15694, 15678, 15768, 15335, 13231, 12136, 11936, 6008, -105, -994, 1089, 2041, 2956, 3759, 4485, 5153, 5775, 6358, 6906, 7425, 7916, 8384, 8827, 9251, 9654, 10039, 10405, 10753, 11085, 11401, 11700, 11983, 12252, 12504, 12743, 12967, 13175, 13371, 13551, 13718, 13870, 14009, 14133, 14245, 14342, 14426, 14496, 14553, 14596, 14638, 14585, 15003, 14720, 14607, 14709, 14746, 14783, 14815, 14844, 14871, 14896, 14920, 14941, 14961, 14981, 15000, 15017, 15035, 15051, 15067, 15081, 15095, 15109, 15122, 15136, 15147, 15159, 15170, 15181, 15192, 15202, 15211, 15221, 15230, 15237, 15246, 15253, 14390, 19057, -7712, -36514, -31821, -32713, -32722, -32730, -32738, -32744, -32750, -32755, -32758, -32761, -32764, -32766, -32767, -32768, -32768, -32767, -32766, -32765, -32763, -32760, -32758, -32754, -32750, -32746, -32742, -32737, -32732, -32726, -32721, -32715, -32708, -32701, -32694, -32687, -32679, -32670, -32662, -32654, -32625, -32643, -32461, -28813, -21093, -15012, -9852, -7622, -6478, -4773, -3227, -1758, -377};