/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1181 256 samples */
 
const int16_t AKWF_1181_256_DATA [256] = 
{19072, 18733, 20913, 22163, 23090, 23676, 23964, 24043, 23861, 23509, 23016, 22414, 21729, 20989, 20211, 19415, 18620, 17833, 17069, 16334, 15633, 14971, 14355, 13779, 13250, 12764, 12322, 11921, 11561, 11237, 10950, 10695, 10469, 10273, 10101, 9951, 9822, 9712, 9618, 9540, 9475, 9422, 9378, 9346, 9321, 9303, 9294, 9290, 9292, 9300, 9312, 9330, 9352, 9378, 9409, 9445, 9484, 9528, 9576, 9628, 9684, 9745, 9809, 9878, 9951, 10030, 10113, 10199, 10290, 10386, 10487, 10592, 10702, 10818, 10936, 11060, 11190, 11323, 11461, 11604, 11752, 11904, 12060, 12222, 12389, 12560, 12735, 12914, 13099, 13286, 13481, 13677, 13879, 14085, 14293, 14507, 14725, 14946, 15171, 15400, 15631, 15867, 16106, 16349, 16594, 16843, 17094, 17349, 17607, 17866, 18128, 18393, 18660, 18930, 19201, 19473, 19749, 20026, 20303, 20585, 20864, 21113, 21408, 21684, 21968, 21941, 23742, 17568, -25103, -29148, -29957, -31354, -32143, -32595, -32739, -32680, -32358, -31866, -31232, -30487, -29659, -28776, -27855, -26915, -25976, -25045, -24135, -23255, -22408, -21599, -20836, -20113, -19437, -18804, -18213, -17664, -17156, -16683, -16247, -15843, -15468, -15121, -14799, -14500, -14220, -13959, -13715, -13485, -13269, -13063, -12868, -12682, -12505, -12335, -12171, -12013, -11862, -11716, -11574, -11436, -11304, -11175, -11050, -10930, -10813, -10700, -10591, -10485, -10385, -10287, -10193, -10105, -10019, -9938, -9861, -9787, -9720, -9656, -9595, -9540, -9488, -9442, -9399, -9361, -9327, -9297, -9272, -9252, -9236, -9223, -9216, -9213, -9214, -9219, -9228, -9242, -9260, -9282, -9308, -9337, -9370, -9408, -9449, -9493, -9541, -9593, -9648, -9706, -9767, -9832, -9900, -9970, -10044, -10120, -10199, -10280, -10364, -10449, -10538, -10628, -10720, -10813, -10910, -11006, -11106, -11206, -11307, -11410, -11511, -11610, -11727, -11826, -11931, -11978, -12432, -10914};