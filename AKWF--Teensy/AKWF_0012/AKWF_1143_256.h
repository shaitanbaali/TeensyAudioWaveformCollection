/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1143 256 samples */
 
const int16_t AKWF_1143_256_DATA [256] = 
{13043, 24600, 23455, 26390, 27962, 28867, 29764, 30425, 30949, 31378, 31721, 31998, 32219, 32391, 32525, 32624, 32695, 32740, 32762, 32766, 32755, 32727, 32685, 32632, 32569, 32495, 32416, 32328, 32232, 32130, 32025, 31915, 31799, 31680, 31558, 31431, 31302, 31172, 31037, 30901, 30762, 30624, 30482, 30339, 30196, 30051, 29904, 29756, 29609, 29461, 29311, 29161, 29010, 28858, 28707, 28555, 28401, 28249, 28095, 27942, 27787, 27632, 27477, 27322, 27166, 27011, 26855, 26699, 26543, 26385, 26229, 26071, 25913, 25756, 25597, 25437, 25277, 25118, 24957, 24797, 24637, 24473, 24310, 24147, 23982, 23816, 23650, 23483, 23313, 23144, 22971, 22799, 22623, 22447, 22268, 22087, 21902, 21717, 21527, 21333, 21135, 20936, 20728, 20517, 20301, 20075, 19847, 19607, 19359, 19100, 18829, 18546, 18248, 17931, 17594, 17232, 16841, 16419, 15955, 15436, 14854, 14189, 13408, 12474, 11284, 9605, 7587, -1802, -22195, -28735, -27996, -29702, -30568, -31038, -31499, -31826, -32070, -32258, -32396, -32493, -32556, -32593, -32605, -32597, -32573, -32533, -32480, -32416, -32343, -32261, -32171, -32074, -31970, -31861, -31749, -31631, -31509, -31384, -31256, -31125, -30992, -30857, -30719, -30580, -30438, -30296, -30153, -30007, -29861, -29714, -29566, -29417, -29268, -29119, -28967, -28816, -28664, -28513, -28360, -28208, -28055, -27901, -27748, -27595, -27441, -27287, -27132, -26978, -26823, -26668, -26513, -26358, -26201, -26048, -25893, -25737, -25581, -25426, -25271, -25114, -24957, -24801, -24645, -24488, -24333, -24176, -24018, -23861, -23704, -23547, -23389, -23230, -23072, -22913, -22754, -22595, -22434, -22274, -22113, -21952, -21791, -21628, -21464, -21300, -21135, -20970, -20803, -20634, -20466, -20296, -20123, -19951, -19775, -19598, -19417, -19235, -19051, -18864, -18671, -18477, -18278, -18073, -17863, -17646, -17420, -17184, -16938, -16678, -16398, -16096, -15761, -15381, -14933, -14357, -13663, -10767};