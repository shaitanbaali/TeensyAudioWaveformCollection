/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1155 256 samples */
 
const int16_t AKWF_1155_256_DATA [256] = 
{1009, 3793, 6296, 8615, 11081, 13894, 16848, 19633, 22032, 24141, 26073, 27912, 29524, 30789, 31664, 32237, 32592, 32761, 32708, 32402, 31871, 31183, 30403, 29546, 28618, 27624, 26595, 25576, 24599, 23668, 22787, 21956, 21186, 20492, 19873, 19317, 18814, 18352, 17922, 17519, 17128, 16733, 16320, 15877, 15396, 14874, 14301, 13672, 12989, 12249, 11458, 10627, 9757, 8860, 7948, 7028, 6118, 5228, 4366, 3546, 2777, 2064, 1416, 837, 327, -111, -484, -793, -1044, -1244, -1403, -1529, -1632, -1722, -1810, -1903, -2011, -2141, -2298, -2488, -2712, -2972, -3267, -3594, -3951, -4332, -4730, -5140, -5553, -5961, -6359, -6737, -7090, -7411, -7695, -7939, -8141, -8298, -8413, -8485, -8519, -8517, -8486, -8431, -8357, -8272, -8182, -8094, -8013, -7944, -7893, -7863, -7857, -7876, -7921, -7992, -8087, -8202, -8335, -8481, -8636, -8794, -8952, -9104, -9243, -9368, -9473, -9555, -9613, -9644, -9649, -9626, -9577, -9506, -9413, -9303, -9180, -9045, -8907, -8767, -8630, -8500, -8380, -8274, -8183, -8109, -8054, -8018, -7999, -7996, -8009, -8034, -8069, -8110, -8155, -8200, -8241, -8276, -8300, -8312, -8312, -8295, -8262, -8212, -8145, -8063, -7966, -7856, -7736, -7609, -7477, -7342, -7207, -7076, -6950, -6832, -6724, -6628, -6544, -6472, -6414, -6368, -6333, -6308, -6292, -6284, -6280, -6278, -6277, -6273, -6265, -6252, -6231, -6201, -6161, -6111, -6050, -5979, -5899, -5810, -5712, -5608, -5501, -5390, -5279, -5169, -5062, -4958, -4861, -4771, -4689, -4615, -4550, -4494, -4446, -4407, -4375, -4348, -4326, -4308, -4291, -4274, -4256, -4236, -4212, -4183, -4148, -4107, -4060, -4006, -3945, -3879, -3807, -3730, -3650, -3567, -3483, -3398, -3314, -3234, -3157, -3083, -3014, -2951, -2893, -2842, -2797, -2758, -2724, -2694, -2668, -2646, -2623, -2602, -2610, -1447};