/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1103 256 samples */
 
const int16_t AKWF_1103_256_DATA [256] = 
{14736, 30776, 29136, 30308, 30734, 30992, 31052, 31407, 31746, 32200, 32686, 32564, 31582, 29739, 27746, 25157, 22635, 20840, 19493, 18322, 16851, 15526, 14432, 13346, 12522, 12179, 12153, 11973, 11361, 10291, 9268, 8793, 8118, 7374, 7222, 7619, 7821, 8127, 8375, 8835, 8772, 8598, 8673, 8959, 8992, 8475, 7307, 6260, 4999, 3262, 999, -1331, -4150, -7293, -10074, -11812, -12567, -13534, -14898, -15706, -16732, -17529, -17804, -17567, -16966, -16138, -15030, -14078, -12898, -11509, -10156, -9080, -8143, -6854, -5708, -4579, -3481, -2438, -1809, -1307, -757, -365, -130, -3, -248, -475, -666, -1340, -1046, -128, 646, 1109, 1151, 959, 1238, 1503, 1497, 1445, 1577, 2142, 2939, 3621, 4246, 4409, 4907, 5786, 6990, 8202, 9077, 9865, 10778, 11407, 11444, 10694, 9600, 7929, 5765, 4120, 3048, 2430, 1665, 808, -142, -1617, -2638, -2879, -2885, -2278, -818, 1210, 3621, 6421, 8533, 9654, 9613, 8418, 7074, 5804, 4820, 4128, 3468, 2161, 825, -503, -1578, -2084, -2108, -1725, -1221, -1086, -1106, -1161, -1076, -411, 69, 743, 579, -128, -372, -789, -1176, -1594, -1904, -1733, -1944, -2640, -4265, -6054, -7379, -8390, -8724, -8616, -8957, -9504, -10169, -10879, -11952, -13569, -15234, -16330, -16712, -17144, -17892, -18644, -18519, -18468, -18891, -18944, -18146, -17526, -17821, -17918, -17247, -16502, -15285, -13860, -12415, -11056, -9704, -8651, -8732, -9056, -9548, -10084, -10707, -11003, -10943, -10299, -9022, -7980, -6973, -6318, -6436, -6476, -5737, -4658, -3575, -2942, -2694, -2939, -2901, -2356, -1328, 385, 2133, 3340, 4084, 4532, 4792, 4272, 3150, 2233, 509, -1650, -2957, -3043, -2875, -3163, -4512, -5566, -5962, -6749, -7328, -7794, -8239, -8380, -8442, -7577, -5989, -5382, -5534, -5091, -4697, -4988, -5148, -5135};