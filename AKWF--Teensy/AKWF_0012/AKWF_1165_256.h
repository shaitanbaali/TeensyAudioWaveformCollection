/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1165 256 samples */
 
const int16_t AKWF_1165_256_DATA [256] = 
{359, 1533, 2709, 3910, 5129, 6362, 7620, 8799, 9891, 11020, 12188, 13294, 14398, 15493, 16605, 17558, 18369, 19147, 19909, 20653, 21406, 22212, 23133, 23969, 24734, 25540, 26294, 27007, 27752, 28343, 29029, 29611, 30098, 30599, 31135, 31573, 31947, 32252, 32485, 32647, 32744, 32768, 32727, 32618, 32435, 32194, 31852, 31368, 30823, 30212, 29543, 28814, 28021, 27110, 26122, 25079, 23986, 22844, 21654, 20414, 19327, 18511, 17879, 17401, 17047, 16796, 16624, 16513, 16452, 16432, 16437, 16459, 16499, 16540, 16624, 16747, 16854, 16958, 17050, 17130, 17198, 17252, 17295, 17325, 17339, 17338, 17326, 17299, 17258, 17203, 17133, 17043, 16940, 16824, 16688, 16538, 16375, 16187, 15990, 15773, 15539, 15287, 15015, 14727, 14423, 14093, 13750, 13389, 13004, 12601, 12180, 11736, 11276, 10796, 10292, 9773, 9233, 8670, 8092, 7497, 6876, 6243, 5591, 4919, 4232, 3529, 2808, 2070, 1322, 559, -219, -1006, -1806, -2618, -3440, -4264, -5101, -5943, -6789, -7638, -8495, -9347, -10200, -11049, -11903, -12749, -13591, -14425, -15244, -16046, -16845, -17633, -18407, -19168, -19921, -20651, -21364, -22068, -22752, -23413, -24052, -24668, -25264, -25835, -26378, -26894, -27383, -27844, -28276, -28677, -29053, -29392, -29700, -29977, -30222, -30436, -30619, -30762, -30867, -30942, -30983, -30995, -30962, -30854, -30656, -30418, -30147, -29850, -29516, -29147, -28750, -28312, -27847, -27287, -26675, -26037, -25363, -24666, -23941, -23187, -22457, -21735, -20989, -20219, -19560, -19062, -18686, -18411, -18217, -18088, -18007, -17962, -17940, -17942, -17955, -17975, -17994, -18014, -18027, -18017, -18051, -18103, -18127, -18121, -18097, -18047, -17972, -17868, -17735, -17570, -17370, -17146, -16892, -16595, -16270, -15909, -15509, -15073, -14598, -14085, -13533, -12945, -12316, -11651, -10940, -10191, -9406, -8575, -7713, -6813, -5871, -4903, -3893, -2851, -1785, -661};