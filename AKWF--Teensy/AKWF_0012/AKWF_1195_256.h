/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1195 256 samples */
 
const int16_t AKWF_1195_256_DATA [256] = 
{396, 1522, 2520, 3556, 4551, 5514, 6474, 7584, 8533, 9339, 10072, 10814, 11448, 12011, 12562, 13173, 13707, 14358, 15038, 15660, 16369, 17153, 17988, 18787, 19502, 20052, 20574, 21150, 21999, 22614, 23205, 23699, 24090, 24356, 24647, 24913, 25106, 25557, 26032, 26135, 26234, 26284, 26292, 26356, 26714, 26898, 26950, 27002, 26917, 26787, 26963, 27108, 27011, 27115, 27144, 27260, 27719, 27820, 27927, 28099, 28369, 28907, 29097, 29235, 29338, 29575, 29755, 29772, 29792, 30142, 30692, 30873, 31139, 31678, 31974, 32044, 32354, 32573, 32479, 32498, 32761, 32559, 32274, 32315, 32054, 31610, 31542, 31179, 30604, 30277, 30084, 29480, 28915, 28756, 28280, 27677, 26760, 25501, 24258, 23329, 22663, 21782, 20815, 20211, 19269, 18184, 17250, 16677, 15788, 14945, 14077, 13503, 12817, 11923, 11003, 10191, 9827, 9044, 8111, 7151, 6217, 5427, 4765, 3933, 3084, 2253, 1404, 668, -181, -636, -1207, -1926, -2606, -3246, -3995, -4697, -5411, -5998, -6583, -7183, -7746, -8439, -9193, -9812, -10410, -11001, -11623, -12260, -12866, -13415, -14021, -14933, -15450, -15864, -16318, -16856, -17404, -17941, -18378, -19165, -19646, -19981, -20334, -20755, -21149, -21851, -22267, -22643, -23015, -23621, -23981, -24133, -24272, -24755, -25074, -25368, -25704, -26401, -26891, -27157, -27651, -28167, -28405, -28681, -29381, -29750, -30001, -30401, -30911, -31032, -31303, -31814, -31878, -32094, -32394, -32383, -32261, -32648, -32662, -32363, -32180, -32155, -31798, -31563, -31565, -31408, -31211, -31302, -31189, -30789, -30467, -30302, -29567, -28825, -28259, -27724, -26855, -26074, -25373, -24945, -24219, -23519, -22772, -22451, -21967, -21362, -20897, -20471, -20374, -20073, -19524, -18980, -18296, -17542, -17035, -16047, -15097, -14065, -13156, -12238, -11714, -11083, -10267, -9568, -8923, -8197, -7420, -6609, -5838, -5374, -4905, -4149, -3319, -2481, -1596, -610};