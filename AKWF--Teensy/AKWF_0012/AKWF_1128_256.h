/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1128 256 samples */
 
const int16_t AKWF_1128_256_DATA [256] = 
{19946, 19950, 19952, 19953, 19955, 19955, 19955, 19954, 19953, 19952, 19951, 19948, 19946, 19943, 19940, 19937, 19934, 19930, 19927, 19923, 19919, 19915, 19910, 19906, 19903, 19954, 19638, 21126, 24463, 24141, 24270, 23854, 26723, 28818, 28418, 28485, 28479, 28473, 28468, 28528, 28148, 31161, 33060, 32685, 32746, 32738, 32731, 32723, 32717, 32708, 32700, 32693, 32684, 32676, 32668, 32660, 32652, 32644, 32635, 32627, 32618, 32353, 33597, 28985, -26380, -30990, -29743, -30004, -30006, -30008, -30009, -30009, -30008, -30007, -30005, -30002, -29999, -29996, -29992, -29988, -29984, -29978, -29974, -29968, -29962, -29957, -29950, -29944, -29937, -29931, -29924, -29918, -29910, -29904, -29896, -29889, -29882, -29875, -29867, -29837, -29949, -29463, -25642, -25470, -25514, -25496, -25488, -25481, -25473, -25466, -25459, -25422, -25580, -24885, -21126, -21093, -21105, -21014, -21420, -18678, -16416, -16823, -16740, -16734, -16728, -16589, -17238, -14823, 13760, 16149, 15503, 15639, 15641, 15641, 15643, 15644, 15644, 15643, 15642, 15642, 15641, 15639, 15638, 15635, 15632, 15630, 15628, 15625, 15622, 15620, 15616, 15614, 15611, 15607, 15603, 15600, 15596, 15592, 15589, 15585, 15582, 15578, 15574, 15571, 15567, 15562, 15558, 15555, 15550, 15547, 15542, 15538, 15534, 15530, 15526, 15522, 15518, 15514, 15510, 15506, 15502, 15498, 15494, 15490, 15485, 15481, 15477, 15473, 15469, 15350, 15906, 13842, -10948, -13012, -12454, -12571, -12573, -12574, -12574, -12575, -12574, -12574, -12574, -12573, -12571, -12570, -12569, -12567, -12565, -12564, -12561, -12559, -12557, -12554, -12552, -12549, -12582, -12382, -13214, -16928, -16846, -16848, -16848, -16846, -16841, -16838, -16835, -16831, -16827, -16823, -16819, -16815, -16811, -16807, -16802, -16798, -16794, -16791, -16786, -16782, -16778, -16773, -16769, -16764, -16760, -16755, -16752, -16747, -16742, -16738, -16734, -16729, -16725, -16721, -16716, -16712};