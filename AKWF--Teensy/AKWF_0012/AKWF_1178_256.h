/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1178 256 samples */
 
const int16_t AKWF_1178_256_DATA [256] = 
{274, 848, 2507, 4269, 5582, 6970, 8337, 9685, 11016, 12329, 13616, 14882, 16124, 17333, 18516, 19670, 20788, 21877, 22901, 24020, 23254, 20630, 17964, 15148, 12340, 8995, 7276, 6858, 6276, 5789, 5386, 5083, 4870, 4902, 3944, 3118, 3094, 3158, 3331, 3566, 3830, 4098, 4344, 4543, 4675, 4724, 4675, 4511, 4225, 3819, 3248, 2347, 3140, 5396, 7437, 9487, 11437, 13873, 14660, 14164, 13885, 13579, 13293, 13031, 12814, 12516, 13359, 14349, 14944, 15670, 16438, 17257, 18127, 19074, 20221, 21500, 22840, 24217, 25617, 27022, 28406, 29764, 31062, 32432, 31962, 29914, 27911, 25954, 26408, 25154, 23926, 24075, 23947, 23814, 23654, 23472, 23252, 23136, 21905, 20565, 19665, 18683, 17716, 16758, 15814, 14883, 13971, 13074, 11784, 13066, -1114, -10616, -13536, -17278, -20332, -23203, -24043, -23091, -22042, -20644, -19071, -16806, -16015, -16363, -16383, -16335, -16204, -16000, -15723, -15519, -14176, -12705, -11667, -10533, -9409, -8298, -7197, -6112, -5051, -4012, -2998, -2015, -1060, -138, 750, 1602, 2400, 3303, 2326, -508, -3379, -6397, -9405, -12945, -14858, -15461, -16230, -16898, -17475, -17952, -18334, -18466, -19585, -20569, -20744, -20831, -20804, -20708, -20581, -20448, -20329, -20254, -20241, -20310, -20472, -20743, -21134, -21643, -22313, -23311, -22610, -20443, -18486, -16519, -14646, -12287, -11571, -12137, -12485, -12855, -13202, -13526, -13796, -14149, -13356, -12415, -11867, -11183, -10458, -9679, -8846, -7935, -6822, -5576, -4264, -2912, -1537, -159, 1204, 2540, 3818, 5171, 4689, 2628, 611, -1355, -909, -2172, -3403, -3256, -3388, -3520, -3679, -3859, -4076, -4183, -5407, -6741, -7628, -8599, -9552, -10495, -11424, -12337, -13230, -14098, -14931, -15733, -16505, -17252, -17963, -18638, -19260, -19976, -18876, -16223, -13691, -10985, -8268, -5007, -3341, -2929, -2291, -1666, -1034, -371};