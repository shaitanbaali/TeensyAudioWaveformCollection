/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1161 256 samples */
 
const int16_t AKWF_1161_256_DATA [256] = 
{638, 1844, 2985, 4095, 5138, 6004, 6856, 7676, 8454, 9118, 9685, 10347, 11003, 11642, 12224, 12750, 13218, 13642, 13878, 14106, 14357, 14382, 14390, 14389, 14284, 14248, 14032, 13607, 13005, 11755, 11029, 11415, 12263, 13434, 14830, 16375, 18005, 19688, 21382, 23048, 24656, 26197, 27561, 28660, 29636, 30459, 31121, 31680, 32078, 32283, 32452, 32423, 32346, 32196, 31920, 31551, 31103, 30587, 30009, 29357, 28636, 27912, 27191, 26481, 25794, 25093, 24373, 23688, 23043, 22435, 21869, 21403, 20994, 20614, 20266, 19950, 19664, 19402, 19163, 18944, 18745, 18566, 18397, 18242, 18099, 17970, 17852, 17748, 17662, 17653, 17756, 17957, 18189, 18431, 18686, 18942, 19180, 19391, 19565, 19690, 19762, 19777, 19736, 19644, 19497, 19297, 19054, 18759, 18410, 18011, 17550, 17028, 16436, 15776, 15037, 14224, 13338, 12378, 11352, 10257, 9110, 7923, 6694, 5445, 4186, 2915, 1657, 416, -803, -1989, -3135, -4249, -5291, -6172, -7040, -7831, -8645, -9324, -9880, -10543, -11185, -11818, -12407, -12937, -13409, -13834, -14075, -14306, -14560, -14588, -14601, -14603, -14502, -14469, -14257, -13835, -13236, -11991, -11269, -11655, -12502, -13671, -15065, -16606, -18233, -19915, -21608, -23273, -24880, -26422, -27787, -28886, -29864, -30690, -31355, -31917, -32318, -32527, -32699, -32676, -32602, -32456, -32184, -31819, -31375, -30865, -30284, -29605, -28890, -28170, -27452, -26751, -26035, -25287, -24574, -23890, -23246, -22641, -22068, -21574, -21169, -20789, -20442, -20127, -19841, -19580, -19342, -19123, -18924, -18745, -18577, -18422, -18279, -18151, -18034, -17928, -17843, -17835, -17931, -18106, -18339, -18582, -18839, -19095, -19333, -19546, -19720, -19844, -19917, -19934, -19893, -19802, -19655, -19456, -19215, -18920, -18573, -18175, -17715, -17195, -16607, -15948, -15211, -14401, -13518, -12560, -11538, -10445, -9302, -8120, -6892, -5648, -4392, -3127, -1876, -617};