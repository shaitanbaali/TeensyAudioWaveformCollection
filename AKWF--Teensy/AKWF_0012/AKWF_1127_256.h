/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1127 256 samples */
 
const int16_t AKWF_1127_256_DATA [256] = 
{76, 265, 450, 638, 811, 1044, 1692, 1985, 2245, 2514, 2782, 3049, 3316, 3583, 3851, 4118, 4386, 4652, 4920, 5185, 5453, 5720, 5986, 6253, 6559, 6616, 8291, 9735, 9880, 10268, 10615, 10963, 11312, 11659, 12007, 12356, 12703, 13051, 13399, 13746, 14094, 14440, 14789, 15166, 15325, 18737, 20178, 20384, 20852, 21280, 21709, 22136, 22565, 22994, 23421, 23849, 24277, 24702, 25131, 25558, 25985, 26185, 27672, 24290, -25381, -33422, -31646, -31379, -30869, -30354, -29838, -29323, -28806, -28288, -27771, -27253, -26734, -26216, -25695, -25176, -24657, -24138, -23617, -23097, -22577, -22057, -21537, -21017, -20496, -19975, -19455, -18984, -18200, -19521, -20370, -19502, -18948, -18345, -17744, -17139, -16538, -15935, -15331, -14732, -14129, -13526, -12925, -12322, -11719, -11120, -10517, -9916, -9315, -8712, -8112, -7512, -6911, -6310, -5710, -5108, -4509, -3909, -3309, -2708, -2111, -1509, -910, -312, 287, 886, 1483, 2080, 2692, 3239, 3378, 3866, 4389, 4904, 5419, 5933, 6449, 6961, 7477, 7992, 8505, 9020, 9533, 10047, 10560, 11074, 11587, 12101, 12575, 13295, 12400, 11735, 12367, 12760, 13190, 13619, 14049, 14479, 14910, 15339, 15768, 16197, 16627, 17055, 17484, 17912, 18283, 19026, 16817, 15639, 16292, 16583, 16927, 17274, 17619, 17965, 18311, 18657, 19001, 19348, 19693, 20038, 20384, 20729, 21074, 21256, 22399, 19794, -14797, -17458, -16400, -16297, -16031, -15766, -15498, -15232, -14963, -14696, -14427, -14159, -13890, -13621, -13352, -13082, -12814, -12544, -12274, -12004, -11734, -11464, -11194, -10924, -10653, -10384, -10113, -9843, -9537, -9473, -8218, -5891, -5917, -5691, -5504, -5318, -5129, -4942, -4755, -4568, -4382, -4195, -4008, -3821, -3635, -3448, -3262, -3075, -2888, -2702, -2516, -2330, -2144, -1958, -1771, -1586, -1399, -1214, -1028, -842, -657, -471, -286, -97};