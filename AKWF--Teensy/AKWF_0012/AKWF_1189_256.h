/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1189 256 samples */
 
const int16_t AKWF_1189_256_DATA [256] = 
{7770, 26095, 31602, 28828, 25853, 26981, 26779, 19726, 20267, 24539, 25171, 24329, 23516, 21248, 11385, 3503, 12454, 23340, 24672, 20096, 16557, 18292, 19931, 13760, 13745, 17034, 16282, 9801, 1250, -3469, -7421, -6582, 9063, 23367, 25528, 20695, 16247, 16083, 14961, 7477, 7876, 12262, 13094, 13199, 14170, 13079, 3591, -4351, 4335, 14887, 15961, 11050, 7146, 7910, 5490, -6160, -10068, -8524, -9208, -13433, -17793, -18344, -19162, -15831, 2127, 18520, 21971, 17625, 13530, 13929, 13216, 5718, 5795, 9597, 9804, 8662, 7754, 5578, -4112, -11835, -2726, 8394, 10055, 5850, 2675, 4739, 6893, 2266, 3518, 7325, 6886, 660, -7713, -12300, -16130, -15204, 442, 14669, 16751, 11917, 7523, 7380, 6196, -1392, -1088, 3187, 3918, 2779, 447, -4142, -16287, -25960, -18419, -8733, -8256, -13314, -16965, -15498, -16333, -25510, -26672, -22676, -21352, -23900, -26746, -25825, -25146, -20310, -1014, 16727, 21426, 17995, 14427, 15084, 14527, 7224, 7603, 11791, 12398, 11572, 10798, 8574, -1254, -9120, -173, 10697, 12007, 7408, 3853, 5591, 7267, 1182, 1306, 4779, 4244, -2004, -10320, -14807, -18528, -17455, -1557, 13027, 15503, 11010, 6919, 7119, 6356, -774, -33, 4692, 5867, 6330, 7685, 6845, -2728, -10929, -2483, 7885, 8808, 3752, -304, 302, -2270, -14063, -18095, -16650, -17407, -21680, -26073, -26653, -27507, -24229, -6348, 9956, 13314, 8880, 4716, 5072, 4347, -3134, -3021, 830, 1092, 13, -826, -2929, -12541, -20178, -10979, 233, 1988, -2122, -5211, -3019, -938, -7164, -7735, -5064, -6326, -13217, -22095, -27029, -31077, -30277, -14694, -488, 1603, -3194, -7488, -7418, -8266, -15447, -14720, -9998, -8699, -9018, -10233, -13474, -24150, -32349, -23409, -12428, -10767, -14745, -17403, -15015, -14991, -23350, -23726, -18966, -16888, -18689, -20785, -19159, -17699, -11646};