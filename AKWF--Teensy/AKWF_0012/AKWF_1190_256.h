/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1190 256 samples */
 
const int16_t AKWF_1190_256_DATA [256] = 
{946, 2701, 4423, 6160, 7896, 9607, 11313, 13020, 14684, 16270, 17770, 19185, 20496, 21701, 22891, 24123, 25346, 26505, 27575, 28559, 29442, 30199, 30857, 31450, 31944, 32321, 32590, 32745, 32758, 32625, 32414, 32177, 31868, 31433, 30868, 30187, 29395, 28471, 27444, 26348, 25141, 23803, 22357, 20809, 19160, 17438, 15736, 14134, 12607, 11096, 9597, 8126, 6665, 5202, 3774, 2404, 1071, -241, -1532, -2795, -4057, -5327, -6525, -7598, -8592, -9552, -10483, -11367, -12198, -12999, -13741, -14398, -15019, -15627, -16215, -16787, -17351, -17898, -18345, -18625, -18781, -18875, -18925, -18928, -18900, -18866, -18797, -18665, -18503, -18331, -18144, -17951, -17779, -17640, -17466, -17208, -16917, -16648, -16410, -16186, -15984, -15821, -15667, -15502, -15360, -15266, -15204, -15166, -15152, -15145, -15045, -14778, -14382, -13906, -13364, -12750, -12073, -11362, -10585, -9715, -8789, -7830, -6834, -5813, -4797, -3797, -2752, -1610, -420, 753, 1906, 3052, 4178, 5266, 6337, 7402, 8420, 9360, 10215, 10990, 11669, 12258, 12845, 13490, 14152, 14772, 15331, 15834, 16270, 16614, 16898, 17156, 17357, 17485, 17548, 17543, 17447, 17249, 17022, 16819, 16593, 16290, 15904, 15452, 14934, 14329, 13669, 12979, 12219, 11370, 10448, 9458, 8401, 7299, 6244, 5313, 4476, 3673, 2897, 2156, 1437, 719, 35, -591, -1188, -1775, -2350, -2914, -3497, -4107, -4672, -5139, -5554, -5968, -6388, -6794, -7190, -7593, -7975, -8319, -8665, -9042, -9444, -9872, -10339, -10831, -11264, -11573, -11799, -12003, -12200, -12387, -12578, -12796, -13008, -13186, -13358, -13544, -13734, -13935, -14172, -14451, -14705, -14878, -15019, -15180, -15367, -15562, -15765, -15994, -16216, -16405, -16596, -16809, -17027, -17238, -17443, -17619, -17667, -17513, -17189, -16746, -16198, -15536, -14770, -13928, -12981, -11898, -10720, -9470, -8144, -6754, -5336, -3903, -2394, -723};