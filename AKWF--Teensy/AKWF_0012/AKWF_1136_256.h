/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1136 256 samples */
 
const int16_t AKWF_1136_256_DATA [256] = 
{14060, 13911, 13763, 13615, 13467, 13318, 13169, 13019, 12868, 12718, 12567, 12416, 12265, 12114, 11963, 11811, 11659, 11508, 11314, 11348, 10068, 6458, 3037, -293, -756, -311, -46, 255, 557, 861, 1163, 1467, 1770, 2074, 2379, 2683, 2986, 3290, 3593, 3897, 4200, 4503, 4807, 5109, 5413, 5715, 6017, 6320, 6621, 6922, 7225, 7524, 7826, 8127, 8426, 8733, 8999, 9419, 11251, 11840, 12268, 12737, 13198, 13660, 14123, 14583, 15044, 15503, 15962, 16421, 16880, 17337, 17795, 18251, 18707, 19163, 19619, 20074, 20523, 20997, 21348, 21218, 21051, 20893, 20733, 20571, 20412, 20251, 20089, 19929, 19767, 19606, 18743, 22479, -17572, -35799, -31765, -32312, -32157, -32001, -31845, -31688, -31530, -31373, -31215, -31056, -30897, -30738, -30579, -30419, -30259, -30099, -29939, -29778, -29619, -29459, -29299, -29138, -28977, -28818, -28658, -28498, -28338, -28179, -28019, -27859, -27699, -27540, -27381, -27222, -27062, -26903, -26743, -26586, -26425, -26195, -26376, -23586, -16938, -11754, -7520, -4077, -1267, 1003, 2830, 4303, 5441, 6522, 6373, 4118, 1642, -1003, -1268, -754, -407, -39, 321, 674, 1023, 1364, 1701, 2034, 2363, 2688, 3010, 3329, 3647, 3962, 4275, 4588, 4897, 5206, 5516, 5822, 6128, 6434, 6737, 7042, 7345, 7648, 7951, 8252, 8553, 8860, 9128, 9552, 11386, 11968, 12399, 12868, 13331, 13793, 14255, 14715, 15175, 15635, 16095, 16554, 17012, 17470, 17926, 18385, 18840, 19296, 19752, 20206, 20655, 21131, 21479, 21349, 21182, 21024, 20864, 20704, 20543, 20381, 20221, 20060, 19898, 19738, 19577, 19415, 19254, 19094, 18933, 18772, 18611, 18451, 17832, 20256, 8862, -32651, -30884, -30949, -30828, -30673, -30518, -30363, -30207, -30049, -29892, -29736, -29577, -29420, -29262, -29103, -28945, -28787, -28627, -28469, -28311, -28151, -27994, -27835, -27676, -27515};