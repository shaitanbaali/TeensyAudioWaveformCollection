/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1112 256 samples */
 
const int16_t AKWF_1112_256_DATA [256] = 
{448, 1428, 2473, 3400, 4058, 4483, 4783, 5100, 5621, 6268, 6800, 7190, 7553, 7879, 8244, 8595, 8914, 9215, 9627, 9985, 10177, 10362, 10506, 10902, 11416, 11914, 12502, 12995, 13373, 13771, 14119, 14544, 15005, 15382, 15740, 15976, 16161, 16372, 16687, 17077, 17551, 18247, 19084, 19875, 20621, 21215, 21735, 22291, 22805, 23336, 23880, 24468, 25107, 25659, 26251, 26923, 27477, 28015, 28606, 29083, 29525, 30127, 30696, 31113, 31528, 31992, 32413, 32726, 31209, 29757, 29361, 29434, 30459, 31251, 31379, 30928, 30341, 29647, 29124, 28896, 28649, 28360, 28026, 27536, 26823, 25953, 25272, 24880, 24544, 24024, 23196, 22031, 20797, 19912, 19369, 19008, 18730, 18252, 17531, 16721, 15930, 15241, 14752, 14312, 13839, 13258, 12481, 11800, 11254, 10792, 10537, 10279, 9743, 8986, 8334, 7833, 7501, 7248, 6832, 6340, 5867, 5423, 5081, 4844, 4628, 4374, 3806, 2979, 2320, 1711, 1278, 1150, 1008, 728, 217, -359, -867, -1344, -1794, -2168, -2588, -2974, -2907, -2812, -2932, -3304, -3983, -4810, -5662, -6342, -6828, -7222, -7489, -7794, -8294, -8989, -9907, -10656, -11167, -11544, -11650, -11840, -12259, -12860, -13418, -13629, -13723, -13901, -14163, -14745, -15163, -14959, -14677, -14608, -14824, -15373, -15916, -16433, -16969, -17376, -17548, -17646, -17836, -17833, -17667, -17520, -17509, -17617, -17871, -18297, -18604, -18845, -19190, -19592, -19924, -20311, -20873, -21480, -22083, -22734, -23192, -23536, -23806, -23965, -24000, -23866, -23801, -23782, -23776, -23778, -23883, -24053, -24199, -24315, -24436, -24607, -24696, -24554, -24220, -23863, -23833, -23843, -23836, -23765, -23233, -22805, -22346, -21595, -20801, -19881, -19105, -18541, -18015, -17383, -16495, -15501, -14666, -14153, -13819, -13403, -12783, -12081, -11446, -10664, -9820, -9098, -8139, -7239, -6423, -5137, -3876, -2830, -2078, -1676, -1066, -253};