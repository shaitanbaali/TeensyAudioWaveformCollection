/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1175 256 samples */
 
const int16_t AKWF_1175_256_DATA [256] = 
{1610, 859, 1509, 2990, 4669, 6103, 7483, 8839, 10069, 11155, 12148, 13078, 13951, 14773, 15559, 16316, 17042, 17745, 18425, 19083, 19722, 20344, 20948, 21536, 22109, 22668, 23214, 23747, 24168, 25230, 19707, 18191, 19167, 18761, 18124, 17632, 17214, 16788, 16420, 16151, 15948, 15784, 15652, 15549, 15465, 15395, 15337, 15290, 15250, 15216, 15197, 15155, 14779, 14754, 14743, 14686, 14626, 14576, 14531, 14488, 14450, 14419, 14393, 14368, 14347, 14329, 14311, 14294, 14279, 14265, 14251, 14236, 14223, 14210, 14172, 14306, 13638, 11809, 12037, 11867, 11547, 11221, 10942, 10667, 10401, 10164, 9956, 9765, 9586, 9419, 9262, 9110, 8966, 8826, 8691, 8561, 8425, 8351, 7962, 7568, 7515, 7355, 7177, 7008, 6848, 6691, 6539, 6395, 6259, 6128, 6001, 5878, 5758, 5641, 5527, 5417, 5308, 5201, 5097, 4995, 4895, 4790, 4730, 4262, 4036, 3978, 3834, 3678, 3532, 3393, 3256, 3125, 3001, 2883, 2770, 2661, 2555, 2452, 2352, 2255, 2159, 2066, 1975, 1844, 1982, 527, -649, -483, -800, -1202, -1570, -1906, -2240, -2559, -2847, -3110, -3357, -3593, -3814, -4027, -4232, -4432, -4623, -4810, -4992, -5169, -5342, -5510, -5675, -5843, -5960, -6349, -6704, -6800, -6981, -7175, -7360, -7537, -7710, -7877, -8036, -8189, -8335, -8478, -8617, -8752, -8883, -9011, -9136, -9258, -9447, -9163, -11006, -17317, -16777, -17321, -18418, -19560, -20540, -21493, -22423, -23258, -23993, -24669, -25302, -25894, -26453, -26988, -27500, -27994, -28470, -28929, -29374, -29807, -30225, -30633, -31028, -31414, -31790, -31954, -33395, -26451, -22112, -23585, -22742, -21505, -20438, -19514, -18585, -17730, -17018, -16417, -15880, -15392, -14953, -14549, -14170, -13814, -13476, -13156, -12851, -12560, -12281, -12014, -11756, -11508, -11269, -11036, -10813, -10595, -10383, -10177, -9977, -9781, -9591, -9402};