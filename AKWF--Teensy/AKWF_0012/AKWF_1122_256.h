/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1122 256 samples */
 
const int16_t AKWF_1122_256_DATA [256] = 
{306, 1316, 2313, 3316, 4321, 5320, 6309, 7283, 8238, 9181, 10098, 10996, 11873, 12727, 13561, 14378, 15168, 15947, 16706, 17445, 18171, 18878, 19572, 20254, 20920, 21571, 22213, 22838, 23452, 24055, 24645, 25222, 25788, 26340, 26880, 27410, 27923, 28429, 28919, 29395, 29862, 30314, 30751, 31175, 31589, 31983, 32304, 33029, 28137, 24733, 23941, 19530, 15281, 11345, 8399, 5871, 3176, 641, -1753, -4044, -6202, -8226, -10084, -11777, -13304, -14672, -15890, -16970, -17922, -18764, -19503, -20155, -20728, -21233, -21672, -22060, -22396, -22691, -22947, -23164, -23351, -23505, -23634, -23736, -23810, -23862, -23888, -23893, -23876, -23836, -23774, -23687, -23583, -23456, -23306, -23135, -22943, -22731, -22498, -22240, -21962, -21661, -21339, -20994, -20626, -20234, -19818, -19376, -18906, -18415, -17888, -17333, -16741, -16112, -15442, -14724, -13951, -13114, -12205, -11205, -10090, -8836, -7460, -6050, -4677, -3356, -2096, -893, 247, 1326, 2341, 3296, 4184, 5001, 5756, 6440, 7061, 7621, 8121, 8563, 8955, 9296, 9595, 9850, 10066, 10250, 10400, 10523, 10617, 10688, 10737, 10767, 10778, 10774, 10755, 10720, 10675, 10621, 10557, 10484, 10402, 10316, 10224, 10128, 10027, 9923, 9817, 9709, 9601, 9492, 9383, 9274, 9167, 9062, 8945, 8921, 7678, 6803, 6528, 5519, 4591, 3767, 3166, 2663, 2150, 1680, 1249, 849, 477, 135, -174, -457, -711, -940, -1148, -1337, -1512, -1672, -1824, -1968, -2106, -2241, -2374, -2505, -2637, -2771, -2904, -3041, -3182, -3326, -3472, -3624, -3779, -3939, -4101, -4269, -4439, -4612, -4790, -4969, -5152, -5337, -5522, -5709, -5897, -6085, -6270, -6453, -6635, -6815, -6990, -7158, -7319, -7471, -7613, -7746, -7864, -7966, -8048, -8107, -8141, -8145, -8113, -8038, -7910, -7721, -7460, -7104, -6631, -6010, -5241, -4385, -3485, -2561, -1620, -641};