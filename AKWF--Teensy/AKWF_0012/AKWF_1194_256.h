/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1194 256 samples */
 
const int16_t AKWF_1194_256_DATA [256] = 
{309, 1049, 1805, 2590, 3397, 4228, 5077, 5936, 6807, 7684, 8557, 9428, 10293, 11144, 11983, 12805, 13605, 14390, 15151, 15886, 16600, 17290, 17954, 18598, 19215, 19809, 20383, 20935, 21467, 21982, 22479, 22961, 23429, 23885, 24329, 24767, 25197, 25622, 26045, 26467, 26892, 27319, 27753, 28197, 28649, 29113, 29592, 30086, 30593, 31112, 31628, 32226, 32408, 31602, 30789, 29965, 29117, 28246, 27343, 26408, 25441, 24435, 23397, 22324, 21215, 20076, 18907, 17705, 16480, 15229, 13955, 12664, 11354, 10027, 8692, 7344, 5988, 4629, 3263, 1894, 527, -846, -2207, -3588, -4919, -3729, -1611, 339, 2319, 4293, 6272, 8237, 10221, 12125, 12261, 11835, 11514, 11165, 10814, 10459, 10101, 9742, 9380, 9021, 8662, 8305, 7951, 7602, 7256, 6918, 6584, 6255, 5934, 5621, 5314, 5014, 4720, 4434, 4153, 3875, 3598, 3322, 3037, 2741, 2431, 2097, 1741, 1358, 945, 501, 32, -470, -994, -1539, -2101, -2678, -3263, -3854, -4444, -5031, -5610, -6176, -6731, -7267, -7785, -8285, -8761, -9213, -9643, -10048, -10430, -10788, -11122, -11432, -11722, -11991, -12239, -12469, -12683, -12882, -13065, -13238, -13399, -13553, -13701, -13842, -13982, -14121, -14262, -14407, -14558, -14719, -14887, -15070, -15265, -15477, -15701, -15937, -16185, -16439, -16697, -16952, -17195, -17426, -17635, -17818, -17973, -18095, -18183, -18235, -18255, -18238, -18189, -18106, -17991, -17847, -17676, -17481, -17266, -17029, -16764, -17516, -18715, -19825, -20941, -22048, -23152, -24254, -25352, -26450, -27549, -28645, -29745, -30812, -32043, -32341, -30544, -28767, -26987, -25201, -23415, -21619, -19822, -18022, -16214, -14406, -12592, -10885, -8487, -9685, -15710, -14877, -14240, -13611, -12972, -12337, -11704, -11079, -10459, -9844, -9238, -8638, -8045, -7459, -6878, -6306, -5742, -5177, -4614, -4052, -3482, -2900, -2306, -1686, -1048, -367};