/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1171 256 samples */
 
const int16_t AKWF_1171_256_DATA [256] = 
{32765, 32767, 32768, 32767, 32767, 32763, 32759, 32754, 32748, 32740, 32535, 33332, 30164, -10236, -17636, -15901, -16244, -16247, -16248, -16249, -16247, -16247, -16241, -15510, -19506, 6341, 36215, 31904, 32698, 32695, 32691, 32685, 32679, 32673, 32665, 32658, 32046, 35375, 16289, -18746, -15809, -16315, -16327, -16329, -16330, -16330, -16331, -16329, -15796, -18790, -6319, 34784, 32161, 32605, 32610, 32607, 32602, 32596, 32590, 32582, 32575, 32567, 32559, 32550, 32542, 32532, 32523, 32514, 32503, 32493, 32482, 32472, 32462, 32451, 32439, 32429, 32419, 32408, 32398, 32387, 32376, 32365, 32355, 32344, 32333, 31952, 34008, 25509, -17494, -16577, -16613, -16664, -16668, -16670, -16673, -16674, -16673, -16673, -16674, -16672, -16669, -16668, -16665, -16663, -16660, -16656, -16653, -16650, -16645, -16641, -16637, -16633, -16628, -16625, -16619, -16615, -16611, -16606, -16602, -16598, -16593, -16589, -16583, -16580, -16575, -16569, -16565, -16560, -16556, -16551, -16547, -16541, -16536, -16532, -16528, -16523, -16519, -16514, -16510, -16505, -16500, -16496, -16492, -16488, -16483, -16479, -16474, -16469, -16467, -16461, -16458, -16453, -16449, -16445, -16440, -16437, -16432, -16428, -16424, -16420, -16416, -16412, -16408, -16403, -16400, -16397, -16393, -16388, -16385, -16381, -16379, -16374, -16370, -16366, -16364, -16359, -16356, -16353, -16350, -16345, -16342, -16339, -16336, -16332, -16329, -16326, -16321, -16319, -16315, -16313, -16309, -16306, -16304, -16299, -16298, -16293, -16290, -16288, -16284, -16282, -16279, -16276, -16273, -16271, -16269, -16266, -16262, -16260, -16257, -16255, -16253, -16250, -16247, -16245, -16241, -16240, -16238, -16235, -16232, -16231, -16228, -16225, -16224, -16222, -16220, -16216, -16214, -16213, -16210, -16208, -16207, -16206, -16202, -16200, -16200, -16198, -16196, -16194, -16191, -16190, -16189, -16187, -16185, -16184, -16183, -16181, -16179, -16178, -16177, -16175, -16173, -16171, -16183, -16096, -16583, -16848};