/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1150 256 samples */
 
const int16_t AKWF_1150_256_DATA [256] = 
{496, 1641, 2880, 4228, 5647, 7095, 8540, 9957, 11320, 12615, 13831, 14961, 16004, 16981, 17895, 18765, 19589, 20386, 21166, 21931, 22685, 23411, 24120, 24803, 25447, 26051, 26616, 27129, 27593, 28011, 28387, 28728, 29021, 29260, 29442, 29509, 29448, 29275, 29023, 28720, 28396, 28080, 27783, 27501, 27243, 27004, 26781, 26566, 26363, 26171, 26003, 25852, 25732, 25633, 25565, 25524, 25511, 25497, 25460, 25487, 25532, 25577, 25603, 25538, 25335, 25036, 24639, 24169, 23662, 23115, 22553, 22009, 21483, 20981, 20530, 20152, 19842, 19603, 19432, 19330, 19303, 19324, 19375, 19443, 19510, 19555, 19566, 19528, 19432, 19273, 19045, 18744, 18381, 17962, 17486, 16966, 16391, 15758, 15079, 14380, 13647, 12866, 12053, 11231, 10414, 9604, 8816, 8022, 7232, 6512, 5826, 5182, 4663, 4193, 3797, 3513, 3291, 3084, 2757, 2533, 2505, 2513, 2548, 2608, 2692, 2707, 2715, 2694, 2655, 2607, 2540, 2410, 2158, 1781, 1316, 754, 74, -727, -1652, -2695, -3841, -5065, -6335, -7618, -8869, -10060, -11143, -12095, -12898, -13545, -14042, -14405, -14646, -14786, -14848, -14840, -14784, -14688, -14570, -14435, -14295, -14172, -14084, -14060, -14130, -14312, -14622, -15070, -15662, -16371, -17170, -18064, -19083, -20197, -21389, -22622, -23881, -25139, -26361, -27516, -28596, -29568, -30413, -31121, -31689, -32137, -32506, -32694, -32770, -32720, -32565, -32317, -31974, -31568, -31102, -30593, -30077, -29536, -28973, -28406, -27829, -27235, -26645, -26067, -25487, -24912, -24337, -23767, -23221, -22687, -22169, -21669, -21184, -20719, -20274, -19848, -19451, -19087, -18767, -18497, -18274, -18102, -17979, -17874, -17773, -17675, -17582, -17491, -17374, -17224, -17042, -16824, -16576, -16291, -15967, -15609, -15228, -14779, -14315, -13858, -13256, -12576, -11836, -10964, -9869, -8749, -7680, -6678, -5773, -5034, -4475, -3840, -3087, -2307, -1446, -493};