/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1121 256 samples */
 
const int16_t AKWF_1121_256_DATA [256] = 
{172, 713, 1276, 1878, 2520, 3212, 3956, 4751, 5600, 6496, 7434, 8405, 9403, 10417, 11438, 12444, 13423, 14367, 15279, 16170, 17058, 17938, 18798, 19630, 20430, 21202, 21963, 22714, 23452, 24176, 24877, 25557, 26217, 26853, 27463, 28047, 28600, 29121, 29609, 30059, 30472, 30852, 31205, 31531, 31822, 32076, 32293, 32474, 32619, 32721, 32767, 32753, 32680, 32554, 32384, 32165, 31893, 31562, 31173, 30729, 30240, 29712, 29156, 28575, 27971, 27378, 26837, 26355, 25893, 25400, 24864, 24312, 23778, 23276, 22793, 22307, 21809, 21302, 20785, 20261, 19737, 19214, 18692, 18168, 17639, 17115, 16605, 16110, 15628, 15156, 14684, 14212, 13741, 13272, 12811, 12362, 11921, 11489, 11061, 10633, 10208, 9782, 9354, 8926, 8497, 8072, 7651, 7232, 6809, 6387, 5966, 5543, 5124, 4702, 4274, 3842, 3403, 2961, 2518, 2073, 1631, 1193, 757, 317, -127, -576, -1022, -1462, -1895, -2323, -2753, -3188, -3624, -4057, -4487, -4910, -5333, -5752, -6168, -6583, -6992, -7396, -7796, -8193, -8581, -8963, -9345, -9788, -10408, -11263, -12262, -13247, -14126, -14949, -15816, -16770, -17775, -18755, -19648, -20454, -21198, -21901, -22588, -23267, -23915, -24500, -25016, -25488, -25955, -26430, -26906, -27366, -27792, -28168, -28492, -28775, -29031, -29272, -29499, -29709, -29893, -30045, -30159, -30239, -30280, -30279, -30243, -30182, -30096, -29984, -29838, -29663, -29466, -29261, -29052, -28829, -28583, -28307, -27996, -27654, -27284, -26896, -26501, -26106, -25704, -25287, -24840, -24370, -23891, -23418, -22961, -22513, -22056, -21573, -21068, -20551, -20039, -19534, -19025, -18501, -17961, -17408, -16854, -16302, -15753, -15205, -14655, -14108, -13571, -13035, -12501, -11968, -11440, -10921, -10413, -9906, -9399, -8892, -8387, -7890, -7400, -6913, -6430, -5951, -5472, -4997, -4529, -4064, -3604, -3148, -2691, -2232, -1769, -1302, -825, -326};