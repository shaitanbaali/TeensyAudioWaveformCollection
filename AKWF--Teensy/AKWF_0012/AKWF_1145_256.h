/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1145 256 samples */
 
const int16_t AKWF_1145_256_DATA [256] = 
{28609, 28236, 28480, 28587, 28708, 28830, 28947, 29061, 29170, 29274, 29379, 29480, 29576, 29668, 29761, 29848, 29933, 30018, 30097, 30172, 30248, 30318, 30389, 30457, 30518, 30586, 30654, 30758, 30892, 31014, 31137, 31255, 31369, 31483, 31594, 31699, 31805, 31906, 32003, 32098, 32191, 32279, 32365, 32450, 32530, 32606, 32673, 32811, 31722, 31084, 30824, 30488, 30162, 29838, 29514, 29192, 28873, 28555, 28236, 27919, 27606, 27292, 26981, 26670, 26361, 26053, 25747, 25441, 25139, 24838, 24535, 24237, 23938, 23642, 23347, 23052, 22761, 22472, 22182, 21894, 21607, 21322, 21037, 20757, 20476, 20195, 19917, 19641, 19365, 19093, 18820, 18549, 18280, 18011, 17746, 17481, 17216, 16953, 16693, 16433, 16176, 15920, 15661, 15409, 15156, 14906, 14657, 14407, 14160, 13902, 13529, 14183, -4150, -9646, -8418, -8642, -8648, -8651, -8654, -8656, -8657, -8659, -8658, -8658, -8658, -8749, -8287, -10014, -27702, -28859, -28537, -28612, -28614, -28614, -28613, -28611, -28604, -28596, -28585, -28573, -28559, -28541, -28522, -28503, -28480, -28457, -28430, -28403, -28374, -28342, -28308, -28274, -28238, -28199, -28159, -28116, -28075, -28030, -27982, -27934, -27884, -27832, -27778, -27724, -27668, -27609, -27550, -27488, -27425, -27360, -27294, -27225, -27156, -27086, -27011, -26946, -26782, -26531, -26290, -26049, -25811, -25573, -25337, -25101, -24866, -24634, -24403, -24172, -23944, -23717, -23490, -23268, -23044, -22822, -22601, -22382, -22165, -21950, -21734, -21520, -21309, -21097, -20888, -20680, -20473, -20268, -20064, -19861, -19662, -19462, -19263, -19065, -18869, -18676, -18483, -18291, -18101, -17912, -17724, -17539, -17354, -17169, -16987, -16806, -16628, -16451, -16274, -16098, -15924, -15752, -15581, -15410, -15242, -15075, -14910, -14747, -14582, -14416, -14221, -14313, -8280, -6781, -7111, -7044, -7034, -7025, -7020, -7014, -7008, -7005, -6999, -6994, -6992, -6960, -7120, -6341};