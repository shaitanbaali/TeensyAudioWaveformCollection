/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1179 256 samples */
 
const int16_t AKWF_1179_256_DATA [256] = 
{1708, 4843, 7728, 10500, 13126, 15589, 17866, 19925, 21757, 23324, 24740, 25107, 24161, 23388, 22691, 22080, 21572, 21182, 20924, 20816, 20860, 21092, 21351, 21453, 21550, 21627, 21686, 21725, 21748, 21752, 21720, 21786, 20884, 18905, 17169, 15536, 14039, 12688, 11501, 10496, 9684, 9096, 8596, 9172, 10520, 11088, 11633, 12000, 12207, 12246, 12108, 11789, 11284, 10590, 9717, 8802, 7933, 7106, 6317, 5572, 4871, 4210, 3607, 2950, 3100, 4202, 5130, 5983, 6739, 7384, 7897, 8264, 8471, 8489, 8442, 7426, 5183, 3208, 1395, -238, -1672, -2898, -3897, -4653, -5158, -5421, -5295, -4866, -4454, -4042, -3644, -3259, -2892, -2541, -2230, -1825, -2397, -4054, -5481, -6814, -8026, -9107, -10038, -10803, -11391, -11771, -12066, -11375, -9438, -7738, -6164, -4730, -3458, -2355, -1442, -730, -229, 52, 119, 108, 103, 95, 88, 81, 74, 66, 83, -24, 248, 1537, 2580, 3463, 4186, 4740, 5118, 5311, 5309, 5088, 4776, 3471, 918, -1387, -3551, -5556, -7379, -9017, -10448, -11657, -12646, -13379, -14013, -14744, -15414, -16040, -16627, -17174, -17680, -18149, -18598, -18897, -20113, -22352, -24298, -26091, -27699, -29112, -30315, -31286, -32018, -32477, -32778, -32103, -29632, -26818, -24229, -21737, -19401, -17234, -15264, -13516, -11999, -10730, -9713, -8806, -7935, -7106, -6318, -5574, -4872, -4210, -3574, -3073, -1841, 266, 2123, 3839, 5385, 6754, 7931, 8897, 9647, 10147, 10525, 9881, 7959, 6249, 4652, 3183, 1866, 708, -269, -1052, -1630, -2014, -2054, -1837, -1681, -1546, -1416, -1294, -1177, -1064, -974, -776, -1537, -3366, -4948, -6419, -7754, -8941, -9965, -10808, -11463, -11898, -12237, -11582, -9673, -7992, -6431, -5005, -3736, -2632, -1714, -997, -485, -193, -114, -112, -103, -96, -89, -82, -76, -69, -59, -67};