/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1192 256 samples */
 
const int16_t AKWF_1192_256_DATA [256] = 
{383, 1856, 3383, 4953, 6525, 8103, 9682, 11227, 12734, 14234, 15718, 17151, 18504, 19775, 20967, 22071, 23112, 24163, 25226, 26255, 27225, 28134, 28976, 29732, 30392, 30996, 31543, 32004, 32356, 32608, 32748, 32755, 32651, 32497, 32300, 32020, 31633, 31144, 30553, 29842, 29006, 28088, 27095, 26000, 24790, 23488, 22098, 20629, 19128, 17667, 16266, 14896, 13528, 12178, 10851, 9525, 8206, 6938, 5721, 4534, 3362, 2208, 1070, -69, -1192, -2231, -3180, -4078, -4945, -5780, -6583, -7370, -8149, -8881, -9563, -10232, -10910, -11586, -12263, -12942, -13587, -14133, -14570, -14934, -15260, -15540, -15779, -16000, -16206, -16362, -16465, -16548, -16631, -16711, -16798, -16915, -17044, -17124, -17149, -17161, -17186, -17218, -17259, -17328, -17430, -17524, -17605, -17700, -17824, -17958, -18097, -18236, -18333, -18315, -18167, -17926, -17616, -17231, -16773, -16260, -15698, -15049, -14309, -13513, -12681, -11806, -10907, -10005, -9080, -8078, -6996, -5874, -4748, -3611, -2471, -1356, -271, 817, 1901, 2948, 3931, 4850, 5707, 6493, 7240, 8018, 8829, 9632, 10400, 11132, 11824, 12458, 13023, 13558, 14067, 14516, 14886, 15184, 15397, 15505, 15530, 15532, 15517, 15447, 15293, 15062, 14752, 14345, 13834, 13263, 12635, 11922, 11113, 10224, 9263, 8236, 7188, 6190, 5260, 4367, 3482, 2620, 1782, 946, 119, -660, -1392, -2096, -2793, -3477, -4154, -4843, -5524, -6133, -6664, -7156, -7633, -8091, -8533, -8976, -9426, -9846, -10236, -10630, -11049, -11486, -11943, -12419, -12881, -13260, -13547, -13780, -13990, -14169, -14321, -14467, -14612, -14713, -14774, -14820, -14871, -14922, -14984, -15076, -15178, -15227, -15218, -15189, -15166, -15139, -15111, -15100, -15108, -15093, -15051, -15005, -14971, -14931, -14878, -14805, -14673, -14407, -13992, -13467, -12854, -12149, -11355, -10489, -9559, -8529, -7394, -6191, -4943, -3644, -2316, -949};