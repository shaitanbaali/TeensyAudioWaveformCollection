/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1118 256 samples */
 
const int16_t AKWF_1118_256_DATA [256] = 
{237, 809, 1510, 2146, 2540, 2895, 3444, 4117, 4751, 5306, 5834, 6366, 6874, 7357, 7836, 8297, 8741, 9186, 9617, 10038, 10459, 10869, 11272, 11673, 12067, 12453, 12838, 13215, 13586, 13954, 14314, 14668, 15017, 15359, 15693, 16022, 16343, 16657, 16966, 17257, 17597, 18109, 18554, 18788, 18913, 19097, 19326, 19538, 19743, 19959, 20170, 20375, 20588, 20786, 20978, 21169, 21345, 21511, 21672, 21819, 21954, 22082, 22193, 22293, 22382, 22457, 22518, 22452, 22313, 22291, 22387, 22460, 22463, 22441, 22416, 22362, 22287, 22199, 22087, 21959, 21820, 21664, 21494, 21316, 21121, 20923, 20625, 20219, 19909, 19736, 19576, 19345, 19087, 18832, 18557, 18265, 17965, 17651, 17324, 16994, 16653, 16304, 15953, 15595, 15231, 14866, 14499, 14126, 13752, 13376, 12997, 12615, 12230, 11841, 11447, 11050, 10646, 10237, 9821, 9397, 8966, 8527, 8079, 7621, 7155, 6677, 6191, 5694, 5188, 4671, 4144, 3608, 3062, 2507, 1941, 1368, 785, 196, -400, -1005, -1617, -2232, -2854, -3476, -4091, -4697, -5293, -5874, -6439, -6987, -7514, -8022, -8507, -8970, -9410, -9828, -10222, -10596, -10948, -11281, -11597, -11894, -12174, -12439, -12687, -12920, -13137, -13340, -13528, -13704, -13864, -14014, -14151, -14282, -14434, -14356, -17164, -23343, -26118, -24050, -21105, -20192, -20070, -19562, -19463, -19737, -20034, -20659, -21257, -20436, -20109, -21378, -22973, -23564, -24108, -25429, -27046, -28359, -29510, -30698, -31406, -31708, -31555, -31291, -31357, -31703, -32017, -32476, -32776, -32549, -32009, -31582, -30823, -29683, -28980, -28775, -28520, -28042, -27509, -26966, -26354, -25863, -25408, -24742, -23866, -22980, -22137, -21135, -20037, -19106, -18540, -18182, -17713, -16850, -15770, -14711, -13754, -12980, -12496, -12112, -11359, -10266, -9169, -8254, -7393, -6565, -5776, -5026, -4311, -3630, -2974, -2330, -1716, -1099, -529, -134};