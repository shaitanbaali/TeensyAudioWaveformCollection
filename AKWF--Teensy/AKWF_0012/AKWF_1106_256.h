/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1106 256 samples */
 
const int16_t AKWF_1106_256_DATA [256] = 
{1050, 3150, 5116, 7017, 8873, 10707, 12538, 14356, 16161, 17948, 19703, 21402, 23016, 24528, 25927, 27190, 28312, 29307, 30187, 30951, 31604, 32135, 32518, 32731, 32754, 32599, 32319, 31965, 31546, 31069, 30536, 29938, 29258, 28493, 27633, 26655, 25555, 24326, 22977, 21532, 20006, 18409, 16758, 15051, 13316, 11591, 9912, 8332, 6887, 5574, 4373, 3259, 2217, 1259, 408, -320, -901, -1318, -1573, -1646, -1521, -1205, -745, -213, 326, 827, 1272, 1649, 1968, 2245, 2465, 2601, 2623, 2497, 2183, 1638, 871, -67, -1099, -2086, -2833, -3154, -2930, -2279, -1901, -2212, -2992, -3881, -4518, -4674, -4310, -3559, -2645, -1713, -657, 694, 2408, 4379, 6358, 8021, 9101, 9542, 9899, 10722, 11833, 12921, 13734, 14104, 13959, 13302, 12194, 10739, 9049, 7205, 5270, 3283, 1261, -786, -2839, -4881, -6872, -8778, -10590, -12284, -13864, -15350, -16754, -18072, -19297, -20409, -21406, -22299, -23086, -23790, -24443, -25050, -25613, -26137, -26641, -27146, -27665, -28197, -28742, -29276, -29763, -30179, -30506, -30745, -30908, -30988, -30972, -30847, -30601, -30224, -29702, -29014, -28131, -27018, -25661, -24069, -22258, -20275, -18149, -15903, -13572, -11179, -8762, -6369, -4033, -1794, 317, 2291, 4089, 5691, 7103, 8331, 9390, 10296, 11055, 11666, 12115, 12390, 12504, 12472, 12327, 12100, 11815, 11497, 11154, 10793, 10450, 10160, 9972, 9921, 10035, 10332, 10793, 11343, 11890, 12314, 12476, 12241, 11522, 10331, 9087, 8272, 7888, 7792, 7790, 7684, 7329, 6658, 5675, 4452, 3083, 1670, 302, -1063, -2537, -4181, -6010, -8004, -10079, -12113, -13975, -15523, -16645, -17295, -17491, -17379, -17383, -17730, -18318, -19012, -19686, -20256, -20688, -20982, -21152, -21206, -21134, -20912, -20522, -19953, -19207, -18296, -17235, -16026, -14672, -13156, -11458, -9587, -7564, -5431, -3251, -1030};