/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1107 256 samples */
 
const int16_t AKWF_1107_256_DATA [256] = 
{288, 1038, 1618, 2339, 3057, 3711, 4288, 5094, 5715, 6263, 6844, 7493, 7965, 8383, 8863, 9377, 9717, 10269, 10745, 11103, 11540, 11877, 12216, 12561, 12950, 13233, 13465, 13863, 14867, 15418, 15871, 16206, 16530, 16775, 17175, 17591, 17863, 18581, 19406, 19613, 19824, 19954, 20024, 20218, 20962, 21417, 21606, 21852, 21917, 21938, 22501, 22900, 22805, 23027, 23016, 23118, 23793, 23761, 23684, 23640, 23750, 24366, 24400, 24422, 24454, 24787, 25006, 24923, 24794, 25116, 25677, 25521, 25496, 25976, 26056, 25764, 25994, 26128, 25775, 25662, 26074, 25772, 25392, 25632, 25451, 25006, 25262, 25059, 24517, 24369, 24463, 23891, 23396, 23598, 23226, 22836, 22921, 22480, 21940, 21696, 21723, 21219, 20581, 20649, 20124, 19416, 18942, 19008, 18426, 17864, 17184, 17000, 16678, 16054, 15282, 14543, 14548, 13858, 13012, 12259, 11578, 11041, 10611, 9786, 8858, 7964, 7075, 6398, 5501, 5250, 4680, 3782, 2945, 2235, 1406, 622, -238, -940, -1760, -2649, -3371, -4222, -5221, -6034, -6864, -7673, -8486, -9290, -10029, -10664, -11440, -12853, -13640, -14290, -14873, -15486, -16120, -16708, -17176, -18418, -19216, -19750, -20249, -20856, -21429, -22520, -23050, -23516, -23933, -24825, -25507, -25917, -26278, -27169, -27675, -27996, -28246, -29082, -29535, -29609, -30166, -30787, -30870, -30906, -31562, -31634, -31514, -31708, -32210, -32047, -32123, -32567, -32268, -32405, -32737, -32498, -32032, -32390, -32205, -31779, -31694, -31892, -31426, -31122, -31200, -30896, -30426, -30501, -30356, -29776, -29378, -29468, -28759, -28165, -27921, -27797, -27053, -26389, -25850, -25768, -25035, -24263, -23388, -23184, -22514, -21506, -20671, -19824, -19595, -19047, -18166, -17412, -16611, -15876, -15699, -14744, -13945, -13036, -12285, -11436, -11242, -10791, -9905, -9098, -8381, -7589, -6808, -5982, -5102, -4759, -4376, -3534, -2721, -1902, -1119, -380};