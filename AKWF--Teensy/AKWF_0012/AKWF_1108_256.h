/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1108 256 samples */
 
const int16_t AKWF_1108_256_DATA [256] = 
{675, 1765, 2522, 3198, 3963, 4715, 5688, 6723, 7578, 7952, 7780, 7583, 7367, 7181, 7180, 7270, 7203, 7030, 7013, 7234, 7941, 9056, 10092, 10989, 11541, 11666, 12260, 12775, 13031, 13567, 13946, 14078, 13697, 12758, 12307, 12063, 11610, 11227, 10907, 10507, 10092, 9650, 9158, 8582, 7725, 7156, 6915, 6657, 6574, 6667, 6717, 6803, 6985, 7228, 7690, 8338, 9297, 10284, 11374, 12460, 13315, 14102, 14795, 15507, 16195, 16536, 16653, 16680, 16786, 17266, 17749, 18226, 18458, 18235, 18372, 18858, 19185, 19802, 20432, 20688, 20774, 20628, 20294, 19817, 19001, 17726, 16365, 15049, 13660, 12304, 11298, 10471, 9580, 8940, 8843, 8485, 7036, 5533, 5078, 4550, 4103, 3557, 3250, 3069, 1704, 402, -731, -1682, -2679, -3704, -4819, -5801, -6620, -7490, -8032, -7937, -7735, -7753, -8027, -8433, -8874, -9336, -9402, -9410, -9651, -9951, -10832, -11825, -12789, -13947, -14812, -15546, -16326, -17019, -17899, -18851, -19661, -20180, -20095, -19716, -19435, -19382, -19409, -19303, -19097, -19095, -19301, -19409, -20144, -21238, -22088, -23211, -23925, -24053, -24525, -24898, -25149, -25595, -25868, -26027, -25781, -25058, -24578, -24230, -23594, -23138, -22942, -22683, -22172, -21671, -21170, -20473, -19885, -19477, -19171, -18735, -18690, -18777, -18617, -18660, -18844, -19234, -19856, -20524, -21514, -22482, -23321, -24440, -25394, -26206, -27051, -27774, -28410, -28548, -28555, -28744, -28996, -29393, -29852, -30210, -30449, -30586, -30918, -31237, -31386, -31931, -32551, -32763, -32696, -32536, -32426, -31976, -30955, -29814, -28596, -27289, -25857, -24490, -23416, -22551, -21735, -21079, -20864, -20472, -19215, -18367, -16593, -15479, -15698, -15436, -15361, -15288, -13932, -12438, -11388, -10494, -9439, -8489, -7445, -6505, -5647, -4722, -4106, -4047, -4241, -4316, -4117, -3740, -3342, -2851, -2488, -2543, -2476, -2117, -1539, -448};