/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1168 256 samples */
 
const int16_t AKWF_1168_256_DATA [256] = 
{1189, 1610, 3004, 3633, 5016, 5640, 6959, 7570, 8780, 9370, 10495, 11087, 12154, 12743, 13753, 14382, 15321, 15996, 16875, 17598, 18446, 19204, 19994, 20810, 21562, 22436, 23125, 24051, 24709, 25687, 26296, 27316, 27881, 28969, 29489, 30615, 31091, 32016, 32268, 32527, 31964, 30807, 28900, 26226, 22927, 18939, 14915, 10418, 6387, 2024, -1502, -3767, -4672, -4822, -4552, -4078, -3527, -2977, -2470, -2018, -1632, -1324, -984, -1318, -3492, -5698, -8611, -10903, -13547, -15356, -17446, -18692, -20220, -20950, -22019, -22340, -23045, -23080, -23501, -23349, -23561, -23273, -23322, -22944, -22883, -22455, -22274, -21826, -21562, -21105, -20756, -20295, -19876, -19430, -18931, -18499, -17931, -17529, -16895, -16497, -15808, -15437, -14679, -14339, -13506, -13191, -12316, -12018, -11085, -10795, -9825, -9556, -8519, -8315, -7044, -6097, -5139, -4255, -3479, -2809, -2247, -1784, -1407, -1104, -858, -697, -409, -148, -853, -653, -1257, -858, -1234, -611, -791, 18, -1, 950, 1041, 2074, 2260, 3334, 3609, 4698, 5011, 6115, 6487, 7579, 7994, 9069, 9540, 10579, 11097, 12107, 12677, 13660, 14273, 15198, 15885, 16775, 17499, 18345, 19126, 19927, 20801, 21329, 21747, 21492, 20823, 19304, 17305, 14812, 11985, 9132, 6055, 3284, 336, -2087, -4682, -5807, -5966, -5623, -5030, -4351, -3672, -3042, -2484, -2006, -1614, -1256, -1122, -1848, -3048, -5067, -6664, -8708, -10023, -11684, -12510, -13732, -14106, -14957, -14971, -15517, -15263, -15595, -15152, -15322, -14734, -14799, -14125, -14089, -13358, -13247, -12490, -12322, -11532, -11307, -10522, -10236, -9450, -9113, -8343, -7954, -7191, -6743, -6011, -5503, -4808, -4229, -3555, -2934, -2290, -1604, -989, -242, 327, 1135, 1671, 2539, 3021, 4037, 3425, 2831, 2319, 1873, 1500, 1193, 941, 738, 576, 447, 335, 338, -346, -621};