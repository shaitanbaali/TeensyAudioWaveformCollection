/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1113 256 samples */
 
const int16_t AKWF_1113_256_DATA [256] = 
{630, 1625, 2453, 3224, 4086, 4741, 5143, 5606, 6210, 7057, 8075, 9202, 10266, 11951, 14220, 16039, 17468, 18423, 19136, 19840, 20691, 21248, 21443, 21723, 22045, 22474, 23005, 23617, 24206, 24967, 25891, 26719, 27366, 27863, 28213, 28460, 28817, 29191, 29450, 29602, 29753, 29858, 30100, 30546, 30878, 31168, 31441, 31666, 31883, 32101, 32166, 32045, 31917, 31705, 31486, 31289, 31080, 30913, 30982, 31250, 31385, 31408, 31387, 31340, 31267, 31148, 30722, 30068, 29519, 29028, 28569, 28096, 27633, 27265, 27033, 26782, 26277, 25781, 25382, 25111, 24854, 24384, 23645, 22821, 22098, 21243, 20286, 19165, 18027, 17140, 16587, 16238, 15921, 15807, 15798, 15823, 15747, 15480, 15053, 14578, 14158, 13710, 13213, 12668, 12154, 11710, 11427, 11333, 11360, 11554, 11711, 11711, 11611, 11362, 10923, 10254, 9336, 8162, 7009, 6034, 5261, 4673, 4222, 3868, 3482, 3126, 2768, 2288, 1575, 560, -643, -1942, -3172, -4647, -6446, -8157, -9668, -10842, -11784, -12638, -13553, -13808, -13427, -13465, -13865, -14679, -15660, -16635, -17487, -18673, -20171, -21490, -22650, -23605, -24404, -25089, -25771, -26205, -26339, -26428, -26603, -26878, -27265, -27706, -28010, -28291, -28674, -29123, -29509, -29928, -30246, -30415, -30717, -31007, -31226, -31411, -31543, -31643, -31852, -32183, -32425, -32644, -32764, -32767, -32722, -32593, -32217, -31657, -31221, -30852, -30460, -30076, -29775, -29571, -29672, -29938, -30023, -30000, -29877, -29693, -29435, -29026, -28429, -27758, -27215, -26569, -25767, -24801, -23780, -22918, -22300, -21761, -21101, -20556, -20117, -19865, -19674, -19286, -18608, -17788, -17019, -16134, -15238, -14371, -13669, -13251, -13081, -13040, -12999, -13021, -13105, -13224, -13304, -13300, -13122, -12746, -12196, -11405, -10577, -9860, -9228, -8706, -8327, -8142, -8166, -8400, -8535, -8413, -8052, -7460, -6649, -5620, -4485, -3212, -1857, -522};