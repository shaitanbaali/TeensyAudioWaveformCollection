/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1147 256 samples */
 
const int16_t AKWF_1147_256_DATA [256] = 
{-1056, 10394, 8333, 8725, 8730, 8734, 8738, 8742, 8746, 8750, 8752, 8754, 8756, 8757, 8757, 8759, 8759, 8759, 8760, 9018, 7396, 14921, 18264, 12177, 13519, 13359, 13386, 13412, 13439, 13465, 13491, 13517, 13544, 13569, 13595, 13620, 13646, 13672, 13697, 13723, 13748, 13773, 13798, 13823, 13849, 13873, 13899, 13923, 13948, 13973, 13998, 14022, 14048, 14073, 14097, 14121, 14147, 14172, 14196, 14220, 14245, 14269, 14294, 14318, 14343, 14367, 14392, 14417, 14441, 14466, 14451, 14415, 14383, 14349, 14316, 14283, 14250, 14217, 14184, 14151, 14118, 14085, 14051, 14018, 13985, 13952, 13918, 13886, 13853, 13820, 13787, 13754, 13721, 13687, 13655, 13621, 13588, 13556, 13523, 13490, 13458, 13424, 13391, 13358, 13325, 13293, 13260, 13227, 13194, 13162, 13129, 13096, 13063, 13030, 12997, 12965, 12933, 12900, 12799, 13138, 9960, 8171, 8526, 8457, 8452, 8448, 8445, 8442, 8438, 8435, 8432, 8429, 8425, 8423, 8420, 8417, 8415, 8412, 8409, 8407, 8404, 8401, 8399, 8330, 8681, 6645, 4437, 4760, 4564, 5272, -10523, -15178, -14255, -14551, -14662, -14773, -14884, -14994, -15102, -15211, -15319, -15427, -15535, -15642, -15748, -15856, -15963, -16068, -16174, -16280, -16385, -16491, -16596, -16701, -16807, -16912, -17016, -17120, -17226, -17329, -17433, -17538, -17642, -17745, -17848, -17952, -18057, -18160, -18264, -18367, -18470, -18572, -18676, -18781, -18883, -18986, -19089, -19191, -19294, -19396, -19499, -19601, -19704, -19806, -19907, -20019, -20066, -19920, -19768, -19618, -19467, -19317, -19164, -19013, -18863, -18711, -18561, -18411, -18261, -18110, -17960, -17809, -17659, -17508, -17359, -17208, -17057, -16908, -16760, -16610, -16459, -16309, -16159, -16009, -15858, -15710, -15562, -15412, -15262, -15112, -14964, -14816, -14666, -14515, -14368, -14220, -14070, -13920, -13773, -13624, -13475, -13328, -13179, -13028, -12892, -12682};