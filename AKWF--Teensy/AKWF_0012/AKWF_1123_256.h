/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1123 256 samples */
 
const int16_t AKWF_1123_256_DATA [256] = 
{2652, 7889, 13438, 18933, 23934, 28077, 31042, 32581, 32574, 30980, 27871, 23415, 17928, 11887, 5302, -481, -1212, 1941, 6501, 10100, 11766, 11406, 9312, 5865, 1641, -2730, -7653, -12797, -17691, -21965, -25269, -27414, -28304, -27922, -26336, -23697, -20236, -16231, -11960, -7773, -3954, -855, 1822, 3975, 5406, 6019, 5813, 4867, 3326, 1359, -727, -2855, -5125, -7306, -9222, -10719, -11701, -12134, -12015, -11392, -10348, -8990, -7433, -5822, -4256, -2857, -1718, -852, -193, 218, 386, 322, 83, -269, -664, -1040, -1337, -1544, -1638, -1599, -1439, -1183, -835, -435, -34, 310, 547, 638, 552, 289, -140, -695, -1298, -1946, -2612, -3204, -3649, -3863, -3802, -3430, -2749, -1823, -707, 696, 2302, 4012, 5679, 7191, 8421, 9256, 9619, 9461, 8776, 7585, 5963, 4037, 1928, -145, -2006, -3820, -5408, -6600, -7250, -7270, -6635, -5379, -3586, -1521, 882, 3711, 6713, 9674, 12349, 14538, 16077, 16850, 16787, 15878, 14170, 11769, 8828, 5621, 2153, -883, -1252, 383, 2732, 4565, 5398, 5190, 4095, 2326, 180, -2021, -4494, -7042, -9462, -11544, -13129, -14136, -14518, -14274, -13448, -12120, -10412, -8448, -6385, -4368, -2556, -1087, 164, 1157, 1809, 2077, 1964, 1515, 800, -98, -1046, -1996, -3006, -3962, -4790, -5424, -5829, -5988, -5910, -5615, -5147, -4547, -3875, -3184, -2523, -1939, -1468, -1115, -851, -689, -627, -656, -756, -896, -1051, -1198, -1311, -1389, -1423, -1408, -1347, -1254, -1127, -984, -844, -726, -649, -625, -659, -756, -906, -1094, -1292, -1503, -1716, -1899, -2030, -2089, -2060, -1936, -1711, -1492, -308, 2140, 4903, 7852, 10751, 13395, 15557, 17044, 17723, 17494, 16338, 14287, 11483, 8111, 4411, 750, -2553, -5786, -8639, -10793, -11983, -12047, -10934, -8684, -5465, -1614};