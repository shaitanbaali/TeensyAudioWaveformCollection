/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1193 256 samples */
 
const int16_t AKWF_1193_256_DATA [256] = 
{303, 309, 315, 321, 325, 330, 335, 338, 341, 344, 514, -422, 3740, 17408, 15974, 19280, 29112, 28615, 28797, 28884, 28968, 29052, 29134, 29217, 29298, 29378, 29459, 29539, 29618, 29696, 29775, 29852, 29929, 30008, 30084, 30160, 30236, 30312, 30387, 30462, 30536, 30612, 30690, 30786, 30888, 30988, 31088, 31188, 31287, 31387, 31485, 31584, 31683, 31780, 31877, 31974, 32072, 32167, 32264, 32360, 32454, 32548, 32652, 32715, 32286, 32174, 32116, 31754, 33244, 24529, 14213, 15739, 15372, 15304, 15236, 15168, 15101, 15034, 14967, 14899, 14833, 14765, 14623, 14975, 13199, 3300, 3124, 3118, 3031, 2967, 2903, 2839, 2775, 2711, 2647, 2584, 2519, 2457, 2394, 2331, 2268, 2205, 2143, 2080, 2018, 1955, 1893, 1830, 1768, 1706, 1644, 1582, 1520, 1458, 1396, 1334, 1273, 1210, 1148, 1086, 1026, 964, 901, 1044, -114, 7000, 12985, 10972, 528, -352, -114, -164, -165, -165, -166, -166, -166, -167, -167, -167, -168, -111, -396, 4455, -624, -1078, -1081, -1165, -1248, -1329, -1412, -1494, -1575, -1657, -1740, -1821, -1903, -1984, -2065, -2147, -2229, -2311, -2393, -2475, -2555, -2636, -2719, -2800, -2882, -2962, -3045, -3125, -3207, -3288, -3369, -3452, -3532, -3614, -3694, -3776, -3857, -4020, -3654, -5580, -15452, -15554, -15595, -15693, -15773, -15853, -15932, -16014, -15994, -15924, -15862, -15798, -15735, -15854, -14752, -27702, -32706, -31539, -31671, -31604, -31538, -31473, -31405, -31338, -31271, -31203, -31136, -31068, -31000, -30932, -30865, -30796, -30729, -30661, -30592, -30524, -30456, -30386, -30318, -30251, -30182, -30112, -30044, -29975, -29906, -29838, -29769, -29701, -29633, -29563, -29495, -29426, -29356, -29288, -29220, -29152, -29083, -29013, -28946, -28877, -28808, -28740, -28672, -28602, -28533, -28464, -28396, -28328, -28260, -28192, -28123, -28054};