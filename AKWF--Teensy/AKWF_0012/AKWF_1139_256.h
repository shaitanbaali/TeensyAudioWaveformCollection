/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1139 256 samples */
 
const int16_t AKWF_1139_256_DATA [256] = 
{136, 3393, 4727, 4837, 5237, 5618, 6024, 6457, 6919, 7400, 7926, 8513, 9123, 9752, 10403, 11074, 11760, 12464, 13189, 13927, 14683, 15453, 16231, 17008, 17900, 18403, 15059, 14964, 15288, 15483, 15676, 15852, 16013, 16155, 16282, 16394, 16492, 16575, 16645, 16703, 16748, 16783, 16806, 16820, 16824, 16819, 16807, 16787, 16761, 16730, 16692, 16650, 16604, 16555, 16503, 16448, 16393, 16335, 16277, 16219, 16162, 16106, 16051, 15997, 15945, 15898, 15851, 15809, 15770, 15734, 15702, 15676, 15652, 15634, 15619, 15611, 15605, 15605, 15611, 15620, 15634, 15653, 15676, 15702, 15734, 15771, 15810, 15852, 15897, 15945, 15995, 16048, 16102, 16156, 16213, 16269, 16325, 16379, 16432, 16482, 16532, 16576, 16618, 16655, 16686, 16710, 16730, 16741, 16743, 16738, 16721, 16694, 16656, 16607, 16544, 16469, 16379, 16273, 16151, 16014, 15900, 15486, 16310, 20109, 19140, 18329, 17514, 16708, 15912, 15131, 14366, 13616, 12880, 12161, 11460, 10779, 10121, 9477, 8857, 8259, 7684, 7132, 6604, 6093, 5608, 5142, 4697, 4279, 3879, 3501, 3139, 2789, 2587, -1448, -3166, -3819, -4715, -5579, -6450, -7325, -8204, -9084, -9961, -10837, -11713, -12585, -13454, -14316, -15165, -16013, -16849, -17676, -18492, -19291, -20075, -20851, -21605, -22344, -23068, -23765, -24446, -25108, -25745, -26360, -26952, -27514, -28056, -28571, -29059, -29520, -29949, -30351, -30726, -31069, -31382, -31664, -31912, -32132, -32318, -32475, -32596, -32686, -32743, -32766, -32757, -32715, -32642, -32534, -32395, -32222, -32016, -31780, -31513, -31213, -30883, -30522, -30132, -29714, -29264, -28787, -28283, -27749, -27194, -26613, -26004, -25372, -24717, -24040, -23347, -22629, -21890, -21136, -20362, -19578, -18777, -17960, -17129, -16289, -15436, -14579, -13710, -12834, -11951, -11065, -10179, -9290, -8399, -7505, -6614, -5728, -4849, -3969, -3098, -2233, -1379, -519};