/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1177 256 samples */
 
const int16_t AKWF_1177_256_DATA [256] = 
{326, 982, 1628, 2277, 2926, 3576, 4231, 4884, 5537, 6194, 6842, 7469, 8089, 8706, 9320, 9931, 10540, 11146, 11743, 12328, 12906, 13481, 14047, 14610, 15173, 15732, 16288, 16839, 17391, 17939, 18486, 19031, 19573, 20113, 20652, 21193, 21730, 22269, 22808, 23340, 23873, 24406, 24938, 25469, 25998, 26525, 27056, 27582, 28107, 28636, 29161, 29683, 30206, 30731, 31027, 32734, 24032, 15807, 14998, 13532, 12391, 11404, 10531, 9759, 9077, 8482, 7961, 7510, 7129, 6807, 6541, 6328, 6165, 6048, 5970, 5933, 5930, 5961, 6027, 6122, 6245, 6392, 6565, 6759, 6976, 7209, 7465, 7736, 8023, 8329, 8647, 8976, 9319, 9675, 10043, 10420, 10811, 11206, 11611, 12027, 12448, 12878, 13317, 13759, 14211, 14668, 15129, 15597, 15646, 18289, 5184, -3188, -4890, -7454, -9366, -10994, -12394, -13548, -14476, -15203, -15744, -16137, -16392, -16529, -16567, -16516, -16390, -16197, -15956, -15669, -15346, -14995, -14623, -14231, -13826, -13414, -12994, -12568, -12151, -11754, -11366, -10980, -10598, -10221, -9848, -9480, -9114, -8750, -8386, -8026, -7668, -7310, -6951, -6591, -6232, -5870, -5507, -5144, -4775, -4407, -4037, -3662, -3288, -2909, -2525, -2139, -1749, -1359, -966, -568, -165, 238, 645, 1053, 1468, 1886, 2303, 2726, 3152, 3575, 4005, 4439, 4649, 6272, -2507, -10809, -11691, -13228, -14439, -15491, -16426, -17261, -17996, -18647, -19220, -19721, -20149, -20515, -20824, -21077, -21278, -21433, -21543, -21615, -21645, -21640, -21601, -21531, -21431, -21305, -21152, -20976, -20772, -20551, -20311, -20049, -19769, -19473, -19160, -18832, -18492, -18135, -17767, -17386, -16995, -16590, -16177, -15755, -15322, -14879, -14426, -13971, -13503, -13027, -12546, -12049, -11536, -11013, -10477, -9939, -9393, -8837, -8275, -7710, -7136, -6560, -5979, -5375, -4752, -4131, -3498, -2862, -2229, -1591, -954, -301};