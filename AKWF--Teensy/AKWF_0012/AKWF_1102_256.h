/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1102 256 samples */
 
const int16_t AKWF_1102_256_DATA [256] = 
{272, 741, 1209, 1694, 2194, 2712, 3251, 3808, 4389, 4996, 5628, 6292, 6988, 7718, 8489, 9303, 10162, 11075, 12046, 13078, 14184, 15368, 16637, 18007, 19488, 21079, 22691, 24197, 25552, 26767, 27856, 28842, 29746, 30570, 31281, 31850, 32272, 32558, 32719, 32767, 32712, 32558, 32313, 31979, 31567, 31117, 30665, 30224, 29798, 29381, 28974, 28575, 28181, 27793, 27409, 27027, 26650, 26275, 25902, 25532, 25165, 24798, 24434, 24073, 23712, 23354, 22999, 22646, 22295, 21946, 21599, 21256, 20915, 20576, 20241, 19908, 19577, 19250, 18926, 18604, 18286, 17970, 17658, 17349, 17044, 16741, 16443, 16147, 15854, 15566, 15280, 14999, 14722, 14448, 14177, 13911, 13647, 13389, 13133, 12882, 12635, 12391, 12152, 11917, 11686, 11458, 11235, 11020, 10744, 10299, 9739, 9131, 8503, 7856, 7192, 6509, 5760, 4924, 4026, 3079, 2090, 1052, -41, -1194, -2415, -3720, -5112, -6580, -8121, -9769, -11565, -13553, -15712, -17881, -19892, -21692, -23308, -24772, -26113, -27369, -28535, -29546, -30368, -31001, -31457, -31757, -31911, -31932, -31825, -31596, -31247, -30795, -30306, -29828, -29375, -28944, -28533, -28137, -27753, -27379, -27013, -26654, -26299, -25948, -25603, -25259, -24918, -24580, -24244, -23911, -23580, -23251, -22924, -22600, -22277, -21956, -21638, -21322, -21007, -20696, -20386, -20080, -19776, -19474, -19174, -18878, -18584, -18292, -18003, -17717, -17434, -17154, -16876, -16601, -16329, -16059, -15793, -15530, -15269, -15012, -14757, -14505, -14257, -14011, -13768, -13528, -13291, -13058, -12827, -12598, -12373, -12151, -11932, -11716, -11503, -11292, -11085, -10881, -10679, -10480, -10285, -10093, -9903, -9717, -9533, -9352, -9174, -8999, -8827, -8658, -8491, -8328, -8168, -8009, -7855, -7705, -7528, -7274, -6970, -6649, -6323, -5994, -5663, -5330, -4975, -4588, -4183, -3767, -3345, -2916, -2480, -2037, -1585, -1124, -653, -176};