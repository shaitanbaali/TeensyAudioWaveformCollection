/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1184 256 samples */
 
const int16_t AKWF_1184_256_DATA [256] = 
{5710, 13861, 21171, 27196, 31225, 32786, 31846, 28709, 23893, 17983, 11592, 5281, -417, -4974, -7986, -9191, -8399, -5641, -1222, 4083, 9290, 13413, 15916, 16727, 16073, 14283, 11790, 8951, 5985, 3095, 315, -2351, -4777, -6812, -8296, -9274, -10018, -10721, -11352, -11814, -11920, -11590, -10875, -9891, -8764, -7626, -6560, -5645, -4890, -4285, -3887, -4065, -5277, -7829, -11581, -15942, -20117, -23301, -24763, -24074, -21155, -16111, -9468, -1829, 6238, 14075, 21198, 26980, 30679, 31892, 30546, 26971, 21727, 15380, 8555, 1827, -4262, -9171, -12478, -13907, -13267, -10573, -6132, -699, 4740, 9209, 12159, 13514, 13496, 12416, 10731, 8735, 6670, 4682, 2818, 1037, -531, -1761, -2506, -2837, -3012, -3251, -3545, -3790, -3777, -3461, -2871, -2081, -1249, -487, 131, 532, 750, 800, 601, -162, -1964, -5090, -9369, -14254, -18890, -22479, -24324, -23944, -21277, -16450, -9947, -2369, 5679, 13563, 20800, 26737, 30649, 32109, 31062, 27820, 22911, 16917, 10441, 4072, -1692, -6306, -9366, -10611, -9858, -7135, -2753, 2553, 7730, 11852, 14356, 15169, 14524, 12744, 10278, 7463, 4556, 1706, -1043, -3653, -6029, -7993, -9420, -10326, -11015, -11641, -12219, -12619, -12649, -12255, -11481, -10419, -9216, -8020, -6890, -5916, -5105, -4429, -3978, -4104, -5282, -7787, -11482, -15802, -19948, -23093, -24545, -23852, -20907, -15864, -9211, -1583, 6486, 14319, 21441, 27194, 30868, 32046, 30688, 27079, 21791, 15393, 8511, 1724, -4405, -9357, -12734, -14231, -13669, -11036, -6668, -1302, 4056, 8450, 11329, 12628, 12533, 11395, 9639, 7577, 5444, 3408, 1476, -338, -1954, -3226, -4027, -4385, -4600, -4857, -5186, -5423, -5413, -5074, -4467, -3655, -2805, -2016, -1349, -895, -622, -513, -639, -1339, -3064, -6100, -10296, -15078, -19608, -23096, -24820, -24363, -21586, -16653, -10049, -2234};