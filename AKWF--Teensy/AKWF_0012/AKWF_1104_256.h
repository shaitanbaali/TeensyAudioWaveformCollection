/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1104 256 samples */
 
const int16_t AKWF_1104_256_DATA [256] = 
{1150, 3158, 5370, 7340, 9263, 10901, 12418, 13488, 13985, 14575, 14642, 14234, 14026, 14233, 14489, 14838, 14818, 14757, 15120, 14990, 14912, 15027, 14860, 15046, 15050, 15425, 16241, 16859, 16974, 17551, 17966, 17968, 17897, 18251, 17583, 25975, 32810, 32166, 32495, 32658, 32554, 32429, 32193, 31812, 31440, 30794, 29750, 28253, 26529, 24464, 22032, 20027, 18014, 16378, 14728, 13326, 12146, 11040, 10047, 9431, 8963, 8710, 8274, 7873, 7244, 6972, 6537, 6078, 5820, 6019, 5934, 6175, 6227, 6469, 6430, 6199, 5971, 5739, 5192, 4523, 3298, 2090, 687, -1075, -3043, -5165, -7354, -9842, -12108, -13956, -15248, -16201, -17258, -17628, -17991, -18264, -18043, -17672, -16893, -15999, -14779, -13582, -12314, -10856, -9534, -8264, -7251, -6099, -5168, -4345, -3642, -3093, -2811, -2859, -2894, -3256, -3752, -4359, -5155, -6175, -6946, -8275, -9194, -9716, -10376, -10812, -11358, -11935, -12379, -12714, -13199, -13590, -13800, -13901, -13666, -13545, -13094, -12909, -12496, -11951, -11395, -10720, -10233, -9814, -9323, -9101, -9008, -9415, -9948, -10793, -12099, -13181, -14200, -14945, -15590, -16214, -16562, -17175, -17703, -17703, -17847, -17553, -16883, -15828, -14610, -12956, -11465, -10322, -9513, -9461, -9614, -9986, -10368, -10648, -10672, -10806, -10848, -10621, -10427, -9837, -8950, -7859, -6405, -5030, -3617, -2124, -835, 835, 2201, 3801, 5173, 6084, 7255, 8219, 8922, 9835, 10319, 11237, 11714, 12120, 12021, 11618, 11199, 10674, 10082, 9932, 9396, 8946, 8387, 7700, 6898, 5702, 4438, 3180, 2258, 1285, 390, -667, -1180, -1878, -2636, -3490, -3767, -4260, -5006, -5879, -6311, -7019, -7526, -7826, -8163, -8393, -8722, -8907, -9783, -10641, -11702, -12809, -13971, -14926, -15595, -15904, -15655, -15156, -14531, -13509, -12822, -12037, -10827, -9558, -7990, -6561, -4936, -3637, -2152, -566};