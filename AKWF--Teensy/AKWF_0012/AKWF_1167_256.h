/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1167 256 samples */
 
const int16_t AKWF_1167_256_DATA [256] = 
{2208, 3532, 3783, 3985, 4096, 4340, 4749, 4745, 4786, 5022, 6729, 7870, 8153, 8291, 8341, 8410, 8821, 10685, 11152, 11548, 11720, 12277, 14141, 14561, 14705, 14790, 15102, 15173, 15109, 15066, 15785, 17260, 17298, 17597, 17634, 17640, 17403, 18305, 19620, 19552, 19622, 19604, 19592, 19525, 20543, 20534, 20298, 20363, 20343, 20280, 20099, 21196, 21618, 21592, 21617, 21563, 21479, 21472, 22524, 22710, 22678, 22663, 22608, 22476, 22576, 23496, 23365, 15550, 12989, 12339, 11540, 10974, 10524, 10118, 10686, 10933, 10862, 10961, 11065, 11129, 11216, 11380, 11501, 11580, 11903, 12723, 12973, 13221, 13462, 13624, 13788, 14046, 14700, 15026, 15128, 15725, 16121, 16232, 16367, 16447, 16633, 16900, 16939, 16988, 17114, 17495, 18076, 18188, 18269, 18311, 18317, 18634, 18861, 18966, 19075, 19424, 19837, 20167, 20194, 20242, 20217, 20381, 20761, 20758, 20769, 21178, 21311, 21244, 21492, 22017, 21325, 20818, 21158, -11492, -22526, -24849, -27975, -29744, -31204, -31943, -32323, -32667, -32769, -32643, -32107, -31736, -31321, -30456, -29584, -28861, -27991, -26979, -26224, -25440, -24542, -23904, -23361, -22704, -22042, -21612, -20977, -20239, -19795, -19362, -19013, -18629, -18223, -17659, -17270, -17012, -16776, -16415, -16189, -16044, -15401, -15025, -14807, -14603, -14452, -14341, -14177, -13456, -13248, -13138, -13008, -12912, -12824, -12761, -12750, -12571, -11800, -11673, -11612, -11481, -11554, -18500, -20747, -21300, -22017, -22528, -22055, -22054, -22163, -22196, -22210, -22170, -22092, -22075, -20997, -20470, -19931, -18540, -18176, -17852, -17560, -17563, -17991, -17910, -17856, -17651, -17732, -16729, -15772, -15578, -15267, -15133, -14992, -15049, -14279, -12629, -12636, -11762, -10000, -9541, -8966, -8704, -8547, -8439, -8385, -8072, -7886, -8055, -6552, -5240, -4873, -4440, -4336, -4227, -4263, -2337, -1271, -1191, -1002, -508, -316, -279};