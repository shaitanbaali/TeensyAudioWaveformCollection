/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1151 256 samples */
 
const int16_t AKWF_1151_256_DATA [256] = 
{1256, 4173, 6321, 7682, 8905, 12318, 13402, 13104, 12982, 12885, 12924, 13149, 13578, 14205, 14967, 15781, 16718, 17870, 19104, 20210, 21131, 21901, 22564, 23122, 23555, 23880, 24131, 24336, 24511, 24660, 24784, 24920, 25043, 25071, 24999, 24836, 24600, 24308, 23991, 23671, 23355, 23045, 22743, 22450, 22166, 21889, 21581, 21181, 20627, 20013, 19504, 19241, 19369, 19907, 20690, 21463, 22004, 22245, 22242, 22112, 21947, 21737, 21494, 21207, 20989, 23416, 24503, 23764, 23228, 22641, 22080, 21572, 21137, 20785, 20515, 20327, 20219, 20181, 20167, 20118, 20139, 20359, 20687, 20939, 21075, 21146, 21195, 21206, 21149, 21011, 20816, 20568, 20258, 19879, 19417, 18908, 18352, 17756, 17127, 16450, 15741, 15015, 14288, 13578, 12885, 12171, 11458, 10772, 10135, 9559, 9009, 8419, 7729, 7032, 6261, 5097, 3587, 2379, 1637, 1218, 1152, 1524, 2353, 1816, 2808, 5349, 5880, 6657, 7296, 7505, 7126, 6150, 4660, 2757, 576, -1745, -4098, -6376, -8490, -10391, -12042, -13429, -14601, -15611, -16356, -16731, -16846, -16909, -16985, -17045, -17058, -17035, -17010, -16979, -16926, -16840, -16718, -16569, -16402, -16193, -15979, -15820, -15741, -15772, -15939, -16264, -16745, -17359, -18079, -18922, -19919, -21024, -22219, -23477, -24807, -26246, -27827, -29438, -30891, -32014, -32647, -32757, -32499, -32110, -31990, -31336, -28320, -27664, -27814, -27628, -27302, -26803, -26197, -25575, -24969, -24393, -23840, -23297, -22745, -22179, -21601, -21018, -20440, -19870, -19315, -18784, -18313, -17943, -17556, -17004, -16370, -15824, -15396, -15025, -14667, -14325, -14038, -13810, -13624, -13483, -13384, -13312, -13253, -13170, -13079, -12997, -12897, -12783, -12647, -12490, -12308, -12102, -11871, -11611, -11325, -11012, -10702, -10359, -9958, -9594, -9346, -9065, -8709, -8759, -9083, -6650, -5002, -5188, -4944, -4273, -3078, 1218, 2849, -4635, -6298, -2106};