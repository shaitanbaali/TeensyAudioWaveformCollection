/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1146 256 samples */
 
const int16_t AKWF_1146_256_DATA [256] = 
{29308, 29141, 29344, 29451, 29570, 29687, 29802, 29911, 30019, 30126, 30230, 30331, 30431, 30528, 30622, 30715, 30807, 30896, 30983, 31068, 31152, 31233, 31312, 31391, 31467, 31540, 31614, 31684, 31754, 31820, 31887, 31950, 32013, 32076, 32133, 32189, 32246, 32302, 32355, 32405, 32453, 32500, 32547, 32591, 32635, 32678, 32714, 32771, 32601, 32217, 31865, 31508, 31151, 30796, 30444, 30093, 29745, 29397, 29049, 28706, 28360, 28019, 27679, 27341, 27004, 26668, 26336, 26006, 25676, 25347, 25020, 24695, 24373, 24051, 23731, 23411, 23095, 22783, 22471, 22157, 21846, 21537, 21231, 20929, 20625, 20323, 20021, 19725, 19430, 19133, 18840, 18549, 18257, 17972, 17685, 17402, 16688, 18722, 5448, -9659, -7270, -7725, -7727, -7730, -7730, -7732, -7732, -7731, -7730, -7729, -7726, -7724, -7721, -7717, -7713, -7710, -7705, -7701, -7697, -7692, -7686, -7917, -6598, -12786, -26672, -25365, -25594, -25579, -25566, -25551, -25534, -25515, -25495, -25473, -25452, -25427, -25401, -25375, -25347, -25318, -25286, -25255, -25222, -25188, -25154, -25118, -25079, -25041, -25001, -24962, -24918, -24876, -24831, -24788, -24741, -24693, -24645, -24596, -24546, -24495, -24442, -24389, -24334, -24279, -24224, -24166, -24107, -24048, -23988, -23925, -23864, -23802, -23736, -23672, -23606, -23538, -23469, -23401, -23330, -23258, -23186, -23113, -23038, -22966, -22876, -22672, -22451, -22235, -22020, -21805, -21592, -21380, -21169, -20961, -20753, -20547, -20345, -20141, -19938, -19738, -19538, -19341, -19146, -18949, -18755, -18564, -18374, -18186, -17997, -17811, -17625, -17441, -17258, -17076, -16899, -16719, -16543, -16367, -16193, -16021, -15850, -15678, -15509, -15344, -15178, -15013, -14850, -14688, -14527, -14369, -14211, -14055, -13789, -14245, -11044, -5807, -6448, -6320, -6316, -6311, -6306, -6299, -6295, -6290, -6287, -6283, -6278, -6274, -6270, -6267, -6263, -6260, -6256, -6248, -6265, -6183};