/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1144 256 samples */
 
const int16_t AKWF_1144_256_DATA [256] = 
{562, 982, 924, 915, 903, 892, 882, 875, 870, 864, 861, 857, 854, 852, 850, 849, 848, 846, 845, 844, 843, 843, 842, 843, 843, 843, 842, 841, 841, 841, 841, 841, 841, 840, 839, 840, 840, 840, 840, 839, 840, 838, 837, 838, 839, 833, 869, 1003, 1137, 1270, 1405, 1538, 1672, 1805, 1939, 2073, 2206, 2339, 2474, 2607, 2740, 2874, 3007, 3140, 3273, 3407, 3540, 3673, 3805, 3939, 4072, 4204, 4337, 4469, 4601, 4734, 4867, 4999, 5131, 5264, 5396, 5529, 5660, 5791, 5924, 6056, 6187, 6317, 6458, 6537, 6409, 6270, 6451, 4549, 12684, 31115, 28545, 28074, 27285, 26490, 25696, 24903, 24108, 23318, 22525, 21730, 20937, 20143, 19348, 18560, 17766, 16972, 16181, 15386, 14596, 13806, 13013, 12164, 11693, 9577, 2213, 2085, 1977, 1731, 1558, 1428, 1321, 1232, 1081, 937, 795, 648, 523, 506, 500, 494, 488, 483, 479, 474, 471, 469, 466, 465, 464, 463, 463, 465, 465, 467, 469, 471, 475, 478, 482, 487, 493, 498, 505, 513, 519, 527, 535, 544, 553, 563, 572, 565, 554, 543, 540, 488, 352, 218, 85, -49, -183, -317, -451, -585, -719, -853, -987, -1121, -1255, -1389, -1522, -1656, -1790, -1924, -2056, -2190, -2324, -2457, -2590, -2723, -2855, -2989, -3123, -3256, -3388, -3520, -3653, -3785, -3918, -4051, -4182, -4316, -4449, -4580, -4713, -4858, -5140, -4241, -27252, -33152, -30834, -30319, -29525, -28732, -27939, -27143, -26351, -25560, -24763, -23968, -23175, -22377, -21587, -20794, -19998, -19204, -18409, -17615, -16827, -16031, -15238, -14446, -13652, -12862, -12073, -11280, -10487, -9697, -8906, -8119, -7329, -6539, -5749, -4965, -4175, -3387, -2600, -1812, -1029, -232};