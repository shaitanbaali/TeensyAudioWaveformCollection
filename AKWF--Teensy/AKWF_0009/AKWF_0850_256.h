/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0850 256 samples */
 
const int16_t AKWF_0850_256_DATA [256] = 
{-17621, 19454, 35590, 32147, 31885, 36623, 2417, -21297, -16747, -17590, -17591, -17592, -17591, -17590, -17590, -17248, -19064, -8186, 2432, 622, 962, 964, 965, 965, 966, 968, 968, 1019, 741, 1912, 7242, 7162, 7161, 7169, 7159, 7169, 7204, 1845, 752, 1013, 965, 965, 964, 963, 964, 963, 961, 962, 960, 942, 1052, -990, -1789, -906, 1082, 934, 959, 959, 957, 1017, 686, 2081, 8432, 8336, 8335, 8343, 8342, 8341, 8339, 8338, 8337, 8263, 8668, 6885, 705, 989, 945, 940, 836, 1397, -1420, -6141, -5555, -5662, -5554, -6140, -3130, 1434, 822, 936, 936, 936, 936, 936, 936, 935, 934, 979, 739, 2414, 3590, 3596, 1931, 747, 975, 933, 932, 931, 932, 932, 1009, 586, 2621, 6596, 2553, 591, 1004, 928, 907, 768, 1801, -24971, -32208, -30541, -30835, -30832, -30829, -30826, -30822, -30818, -30813, -30241, -33273, -16445, 3498, 398, 982, 987, 1365, -665, 15060, 24923, 22980, 23339, 23338, 23337, 23337, 23335, 23333, 23331, 22996, 24815, 8084, -467, 1297, 973, 971, 969, 967, 965, 963, 961, 960, 959, 957, 939, 976, 955, -8662, -10476, -10036, -10116, -10117, -10116, -10116, -10114, -10113, -10112, -10111, -9938, -10871, -2699, 1700, 803, 968, 969, 969, 971, 972, 1023, 751, 2210, 4117, 3836, 3853, 4051, 1753, 806, 1010, 885, 1363, -2211, -4568, -4109, -4194, -4193, -4193, -4192, -4192, -4192, -4156, -4347, -3563, 945, 996, 970, 979, 980, 980, 981, 1052, 654, 4724, 6594, 6199, 6270, 6270, 6174, 6679, 3877, 556, 1073, 976, 976, 974, 973, 973, 972, 973, 972, 971, 953, 1061, -967, -1759, -882, 1091, 943, 968, 969, 969, 969, 968, 967, 968, 968};