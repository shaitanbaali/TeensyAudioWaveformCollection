/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0826 256 samples */
 
const int16_t AKWF_0826_256_DATA [256] = 
{795, 2077, 3366, 4693, 6048, 7432, 8843, 10266, 11703, 13146, 14578, 16000, 17400, 18763, 20090, 21370, 22591, 23757, 24856, 25882, 26841, 27724, 28531, 29265, 29921, 30504, 31016, 31454, 31824, 32130, 32371, 32552, 32677, 32747, 32768, 32740, 32670, 32557, 32407, 32223, 32006, 31760, 31484, 31183, 30855, 30503, 30124, 29719, 29288, 28829, 28339, 27821, 27268, 26680, 26059, 25397, 24699, 23964, 23188, 22375, 21526, 20640, 19723, 18774, 17794, 16790, 15765, 14716, 13653, 12575, 11482, 10387, 9284, 8178, 7075, 5974, 4879, 3796, 2722, 1662, 621, -403, -1407, -2388, -3345, -4277, -5178, -6051, -6887, -7685, -8440, -9146, -9797, -10389, -10916, -11373, -11758, -12067, -12298, -12452, -12527, -12526, -12452, -12305, -12094, -11819, -11488, -11102, -10673, -10205, -9701, -9169, -8618, -8049, -7470, -6888, -6307, -5730, -5166, -4614, -4079, -3564, -3068, -2592, -2136, -1697, -1275, -868, -472, -86, 289, 656, 1016, 1365, 1705, 2030, 2338, 2625, 2885, 3115, 3308, 3461, 3569, 3633, 3648, 3611, 3525, 3390, 3206, 2977, 2703, 2388, 2037, 1653, 1239, 801, 340, -138, -629, -1130, -1639, -2148, -2658, -3165, -3666, -4156, -4638, -5104, -5558, -5998, -6419, -6821, -7211, -7582, -7938, -8280, -8610, -8931, -9245, -9553, -9860, -10166, -10473, -10786, -11105, -11432, -11769, -12114, -12468, -12831, -13203, -13583, -13969, -14361, -14756, -15155, -15555, -15958, -16360, -16761, -17159, -17557, -17949, -18337, -18720, -19097, -19469, -19833, -20189, -20538, -20880, -21214, -21537, -21854, -22159, -22453, -22731, -22991, -23229, -23439, -23616, -23756, -23852, -23899, -23893, -23831, -23709, -23525, -23281, -22973, -22603, -22174, -21686, -21141, -20544, -19896, -19199, -18461, -17681, -16861, -16010, -15126, -14212, -13274, -12312, -11328, -10326, -9305, -8266, -7212, -6135, -5041, -3925, -2784, -1619, -400};