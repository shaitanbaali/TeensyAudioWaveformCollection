/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0807 256 samples */
 
const int16_t AKWF_0807_256_DATA [256] = 
{10525, 24717, 31527, 32559, 29260, 23134, 15553, 7646, 191, -6278, -11451, -15246, -17689, -18913, -19017, -18720, -18740, -17677, -15787, -13475, -10978, -8487, -6134, -3991, -2110, -515, 803, 1851, 2652, 3248, 3584, 4268, 5657, 6321, 6354, 6022, 5469, 4806, 4104, 3415, 2769, 2183, 1670, 1230, 862, 550, 377, -179, -1637, -2409, -2578, -2405, -2022, -1530, -998, -468, 29, 477, 870, 1202, 1473, 1700, 1802, 2360, 3708, 4396, 4527, 4142, 4724, 6954, 7634, 7218, 6200, 4860, 3403, 1953, 595, -633, -1627, -2891, -4935, -6178, -6709, -6793, -6575, -6165, -5642, -5058, -4452, -3848, -3263, -2709, -2191, -1701, -1322, -478, 1160, 2138, 2527, 2572, 2403, 2119, 1779, 1429, 1095, 791, 527, 339, -15, 1100, 4172, 5076, 3864, 2622, 1563, 646, -122, -748, -1242, -1621, -1895, -2080, -2188, -2228, -2214, -2260, -1777, -3343, -18623, -29638, -32701, -31104, -26571, -20798, -14641, -8564, -2880, 2211, 6608, 10310, 13335, 15700, 17563, 18462, 17972, 17537, 18389, 21455, 22897, 22893, 22002, 20518, 18675, 16635, 14507, 12378, 10297, 8310, 6366, 5049, 4692, 3851, 2590, 1148, -341, -1795, -3159, -4391, -5479, -6415, -7194, -7826, -8317, -8690, -8867, -9375, -10735, -11364, -11350, -10958, -10320, -9545, -8703, -7840, -6965, -6255, -4904, -1439, 831, 1783, 1931, 2122, 2895, 2936, 2404, 1600, 688, -225, -1071, -1806, -2415, -2891, -3239, -3465, -3583, -3617, -3493, -3739, -4878, -5329, -5179, -4691, -4000, -3209, -2389, -1583, -822, -125, 502, 1054, 1529, 1944, 2219, 2936, 4427, 5243, 5456, 5317, 4959, 4479, 3943, 3399, 2871, 2376, 1926, 1523, 1168, 846, 644, 43, -1472, -2311, -2555, -2458, -2155, -1743, -1288, -831, -402, -16, 303, 486, 1448, -8985, -16890, -7184};