/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0833 256 samples */
 
const int16_t AKWF_0833_256_DATA [256] = 
{1687, 4079, 6267, 8330, 10274, 12067, 13662, 15039, 16223, 17240, 18107, 18838, 19437, 19904, 20256, 20515, 20701, 20827, 20898, 20918, 20897, 20842, 20765, 20672, 20565, 20444, 20313, 20174, 20029, 19882, 19730, 19577, 19420, 19259, 19094, 18928, 18759, 18586, 18409, 18228, 18043, 17853, 17659, 17461, 17258, 17051, 16839, 16623, 16403, 16178, 15949, 15718, 15483, 15244, 15005, 14762, 14516, 14269, 14021, 13772, 13521, 13271, 13020, 12769, 12518, 12268, 12019, 11771, 11524, 11280, 11035, 10794, 10554, 10317, 10083, 9850, 9620, 9393, 9169, 8947, 8729, 8514, 8301, 8092, 7886, 7684, 7485, 7288, 7095, 6905, 6719, 6535, 6355, 6178, 6005, 5835, 5668, 5504, 5342, 5184, 5030, 4878, 4729, 4583, 4440, 4300, 4163, 4029, 3896, 3767, 3641, 3517, 3395, 3277, 3161, 3047, 2935, 2826, 2719, 2614, 2512, 2412, 2314, 2219, 2124, 2033, 1943, 1855, 1769, 1685, 1603, 1522, 1444, 1367, 1292, 1219, 1147, 1076, 1008, 941, 874, 811, 748, 686, 627, 568, 511, 455, 400, 346, 295, 243, 193, 145, 97, 51, 6, -38, -81, -123, -164, -204, -244, -282, -319, -355, -391, -426, -459, -493, -525, -556, -587, -617, -645, -674, -702, -729, -756, -781, -806, -830, -854, -877, -900, -929, -996, -1145, -1398, -1756, -2227, -2840, -3634, -4638, -5874, -7324, -8907, -10575, -12339, -14206, -16152, -18111, -20014, -21816, -23488, -25033, -26481, -27805, -28958, -29928, -30724, -31365, -31876, -32268, -32544, -32708, -32768, -32744, -32656, -32515, -32327, -32098, -31834, -31542, -31232, -30909, -30577, -30238, -29892, -29542, -29190, -28839, -28490, -28140, -27793, -27445, -27097, -26752, -26407, -26048, -25636, -25118, -24479, -23723, -22828, -21759, -20479, -18946, -17148, -15128, -12966, -10715, -8353, -5868, -3318, -725};