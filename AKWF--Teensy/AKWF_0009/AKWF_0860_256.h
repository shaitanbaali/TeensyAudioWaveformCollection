/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0860 256 samples */
 
const int16_t AKWF_0860_256_DATA [256] = 
{281, 1117, 1832, 2448, 2962, 3380, 3716, 3988, 4229, 4478, 4772, 5148, 5634, 6252, 7027, 7977, 9077, 10288, 11563, 12858, 14139, 15358, 16471, 17452, 18272, 18926, 19415, 19746, 19927, 19975, 19901, 19722, 19449, 19099, 18683, 18210, 17695, 17145, 16567, 15972, 15365, 14753, 14146, 13545, 12958, 12394, 11855, 11348, 10878, 10450, 10070, 9744, 9477, 9276, 9145, 9091, 9109, 9191, 9327, 9495, 9682, 9872, 10047, 10194, 10301, 10360, 10359, 10294, 10160, 9953, 9670, 9311, 8874, 8360, 7771, 7107, 6365, 5558, 4748, 1929, -1797, -4831, -7660, -10266, -12682, -14911, -16960, -18846, -20572, -22143, -23576, -24875, -26046, -27108, -28063, -28925, -29701, -30396, -31017, -31563, -32029, -32402, -32659, -32769, -32697, -32411, -31891, -31110, -30053, -28710, -27082, -25220, -23180, -21000, -18734, -16433, -14135, -11893, -9739, -7684, -5743, -3918, -2195, -577, 945, 2387, 3752, 5049, 6288, 7475, 8615, 9717, 10780, 11811, 12813, 13788, 14742, 15677, 16592, 17494, 18376, 19272, 20001, 19104, 17857, 16989, 16218, 15545, 14946, 14412, 13932, 13496, 13099, 12731, 12385, 12057, 11737, 11419, 11097, 10762, 10409, 10028, 9614, 9161, 8665, 8124, 7540, 6924, 6284, 5646, 5046, 4523, 4110, 3840, 3739, 3829, 4131, 4652, 5356, 6196, 7128, 8108, 9093, 10043, 10912, 11668, 12298, 12792, 13150, 13383, 13499, 13512, 13430, 13271, 13045, 12763, 12438, 12078, 11691, 11287, 10870, 10447, 10026, 9611, 9201, 8827, 8346, 6751, 4093, 1282, -1476, -4173, -6797, -9328, -11753, -14078, -16285, -18363, -20318, -22131, -23796, -25312, -26663, -27843, -28850, -29666, -30289, -30712, -30925, -30931, -30731, -30335, -29757, -29017, -28137, -27130, -26016, -24815, -23533, -22187, -20795, -19358, -17897, -16422, -14935, -13454, -11986, -10534, -9113, -7730, -6387, -5100, -3873, -2710, -1627, -608};