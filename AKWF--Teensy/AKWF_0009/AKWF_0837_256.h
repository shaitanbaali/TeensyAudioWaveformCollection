/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0837 256 samples */
 
const int16_t AKWF_0837_256_DATA [256] = 
{706, 1866, 2991, 4110, 5217, 6313, 7401, 8474, 9537, 10591, 11631, 12662, 13685, 14693, 15695, 16687, 17667, 18640, 19605, 20558, 21502, 22429, 23323, 24184, 25014, 25812, 26578, 27302, 27980, 28609, 29188, 29720, 30206, 30646, 31038, 31384, 31685, 31945, 32166, 32349, 32497, 32610, 32691, 32743, 32766, 32762, 32734, 32681, 32604, 32506, 32386, 32247, 32089, 31912, 31717, 31504, 31274, 31029, 30768, 30491, 30199, 29892, 29571, 29237, 28888, 28528, 28154, 27767, 27368, 26957, 26533, 26099, 25652, 25193, 24725, 24245, 23752, 23250, 22735, 22210, 21675, 21128, 20569, 20002, 19421, 18834, 18250, 17668, 17091, 16518, 15948, 15387, 14840, 14303, 13785, 13281, 12788, 12310, 11846, 11395, 10958, 10533, 10115, 9709, 9310, 8917, 8533, 8153, 7777, 7408, 7040, 6675, 6315, 5958, 5603, 5253, 4904, 4548, 4176, 3783, 3374, 2949, 2506, 2038, 1542, 1014, 457, -125, -735, -1369, -2026, -2709, -3411, -4129, -4864, -5608, -6362, -7126, -7893, -8663, -9438, -10209, -10981, -11751, -12515, -13278, -14037, -14786, -15532, -16266, -16973, -17644, -18278, -18881, -19451, -19979, -20460, -20890, -21266, -21591, -21869, -22099, -22281, -22417, -22508, -22559, -22574, -22554, -22503, -22424, -22317, -22186, -22033, -21862, -21673, -21468, -21248, -21014, -20768, -20511, -20245, -19984, -19748, -19543, -19365, -19210, -19087, -19005, -18974, -18994, -19067, -19188, -19357, -19572, -19834, -20141, -20488, -20871, -21286, -21726, -22191, -22677, -23180, -23697, -24223, -24754, -25291, -25831, -26369, -26905, -27438, -27963, -28482, -28982, -29446, -29858, -30217, -30528, -30785, -30976, -31090, -31122, -31069, -30932, -30712, -30411, -30026, -29559, -29014, -28394, -27706, -26956, -26146, -25279, -24364, -23403, -22400, -21366, -20298, -19202, -18086, -16946, -15791, -14626, -13446, -12261, -11072, -9876, -8681, -7489, -6297, -5110, -3930, -2755, -1592, -414};