/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0814 256 samples */
 
const int16_t AKWF_0814_256_DATA [256] = 
{1857, 4767, 7443, 10709, 14623, 18572, 22227, 25371, 27918, 29832, 31115, 31810, 31969, 31651, 30919, 29837, 28466, 26850, 25090, 22937, 19577, 15447, 11159, 7028, 3269, -10, -2779, -5027, -6780, -8086, -8986, -9531, -9773, -9763, -9542, -9151, -8628, -8004, -7306, -6548, -5804, -4798, -1774, 2948, 8078, 12933, 17124, 20438, 22795, 24218, 24765, 24536, 23637, 22181, 20281, 18034, 15540, 12886, 10135, 7360, 4614, 1927, -637, -3093, -6266, -10238, -14325, -18157, -21492, -24225, -26315, -27755, -28591, -28873, -28664, -28030, -27035, -25746, -24217, -22502, -20656, -18712, -16711, -14694, -12677, -10691, -8759, -6887, -5100, -3408, -1811, -324, 1049, 2311, 3454, 4483, 5411, 6179, 7169, 9217, 11844, 14496, 16876, 18802, 20205, 21068, 21408, 21272, 20718, 19810, 18606, 17171, 15563, 13828, 12015, 10168, 8314, 6487, 4698, 3030, 1103, -2895, -8460, -14288, -19717, -24365, -28012, -30604, -32168, -32770, -32517, -31528, -29927, -27828, -25338, -22568, -19600, -16514, -13388, -10269, -7203, -4262, -1386, 2287, 6737, 11282, 15534, 19258, 22355, 24773, 26514, 27626, 28159, 28176, 27745, 26934, 25807, 24422, 22838, 21100, 19251, 17337, 15386, 13426, 11489, 9590, 7745, 5977, 4292, 2699, 1208, -185, -1441, -3179, -5821, -8752, -11569, -14057, -16085, -17603, -18613, -19137, -19221, -18918, -18286, -17384, -16259, -14969, -13555, -12055, -10509, -8948, -7390, -5849, -4441, -2243, 1965, 7107, 12464, 17378, 21347, 24325, 26311, 27383, 27628, 27157, 26085, 24492, 22466, 20186, 17733, 15167, 12562, 9710, 8643, 8250, 6264, 4909, 2811, 138, -2721, -5568, -8245, -10671, -12806, -14617, -16106, -17282, -18158, -18757, -19103, -19216, -19123, -18848, -18426, -17824, -17346, -18617, -21337, -24373, -27138, -29298, -30680, -31231, -30980, -29994, -28370, -26207, -23619, -20710, -17565, -14284, -10943, -7602, -4327, -1099};