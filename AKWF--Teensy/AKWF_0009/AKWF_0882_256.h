/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0882 256 samples */
 
const int16_t AKWF_0882_256_DATA [256] = 
{4910, 11855, 17170, 21135, 24057, 26266, 27930, 29034, 29580, 29534, 28815, 27687, 26778, 26478, 26824, 27522, 28140, 28342, 27907, 26940, 25910, 25048, 24310, 23508, 22463, 20788, 18064, 14879, 12448, 11470, 11910, 12989, 13957, 14084, 12836, 10646, 8499, 6799, 5343, 3565, 1110, -1928, -5387, -8500, -10077, -10095, -9211, -8382, -8338, -9205, -10850, -12935, -14904, -16511, -17824, -19063, -20427, -22037, -23872, -24880, -23415, -18886, -11890, -3971, 3399, 9302, 13431, 16097, 17885, 19160, 20029, 20351, 20080, 19109, 17012, 14251, 12070, 11123, 11506, 12621, 13677, 13997, 12989, 10839, 8576, 6771, 5261, 3572, 1295, -1638, -5078, -7892, -8473, -6189, -1479, 4287, 9782, 14152, 17075, 18814, 19903, 20655, 21134, 21168, 20684, 19554, 17341, 14494, 12249, 11255, 11603, 12693, 13729, 14036, 13018, 10861, 8592, 6781, 5267, 3575, 1295, -1638, -5083, -7919, -8528, -6269, -1570, 4202, 9709, 14094, 17031, 18781, 19878, 20636, 21120, 21159, 20676, 19549, 17337, 14491, 12246, 11254, 11602, 12693, 13729, 14036, 13018, 10861, 8593, 6781, 5265, 3571, 1290, -1647, -5084, -8311, -10111, -10212, -9258, -8312, -8152, -9006, -10716, -12810, -14740, -16315, -17605, -18888, -20357, -22066, -23943, -25580, -26436, -26483, -26038, -25577, -25477, -25905, -26774, -27846, -28824, -29629, -30288, -30899, -31510, -32072, -32617, -32472, -30190, -25393, -18698, -11494, -5061, -414, 1919, 2494, 2437, 2305, 2020, 1107, -704, -3267, -6376, -9230, -10616, -10492, -9504, -8597, -8496, -9322, -10937, -12998, -14949, -16545, -17850, -19082, -20442, -22046, -23884, -25115, -24182, -20593, -14927, -8580, -2846, 1251, 3162, 3416, 3117, 2807, 2389, 1381, -502, -3118, -6266, -9149, -10556, -10448, -9472, -8574, -8479, -9309, -10928, -12992, -14946, -16542, -17847, -19079, -20439, -22046, -23876, -24764, -23109, -18411, -11202, -2787};