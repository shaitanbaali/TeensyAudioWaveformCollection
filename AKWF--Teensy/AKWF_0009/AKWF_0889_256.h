/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0889 256 samples */
 
const int16_t AKWF_0889_256_DATA [256] = 
{4351, 7351, 9606, 12708, 16272, 19997, 23565, 26674, 29177, 31023, 32204, 32732, 32645, 31997, 30861, 29320, 27469, 25388, 23154, 20837, 18479, 16112, 13754, 11383, 9008, 6616, 4205, 1799, -539, -2702, -4481, -5601, -5841, -5136, -3474, -796, 2858, 6936, 10948, 14691, 17929, 20357, 21739, 22057, 21384, 19830, 17535, 14682, 11495, 8180, 4966, 2040, -469, -2459, -3881, -4733, -5044, -4879, -4312, -3434, -2332, -1081, 237, 1581, 2914, 4201, 5448, 6647, 7752, 8708, 9481, 10030, 10346, 10419, 10251, 9844, 9206, 8366, 7345, 6178, 4906, 3563, 2190, 826, -552, -1605, -3615, -11909, -13954, -14730, -16257, -17650, -18685, -19233, -19260, -18802, -17942, -16791, -15457, -14047, -12658, -11361, -10200, -9214, -8395, -7731, -7196, -6745, -6350, -5993, -5660, -5342, -5033, -4742, -4507, -4327, -4200, -4126, -4125, -3971, -3774, -3761, -3749, -3740, -3734, -3726, -3722, -3716, -3711, -3706, -3702, -3699, -3694, -3693, -3689, -3687, -3685, -3682, -3680, -3677, -3677, -3673, -3671, -3670, -3669, -3667, -3664, -3665, -3663, -3662, -3661, -3660, -3659, -3656, -3656, -3654, -3654, -3652, -3652, -3650, -3648, -3648, -3646, -3647, -3645, -3643, -3642, -3641, -3641, -3639, -3637, -3638, -3636, -3636, -3635, -3633, -3633, -3631, -3631, -3630, -3628, -3628, -3626, -3627, -3624, -3623, -3623, -3622, -3621, -3620, -3620, -3619, -3617, -3618, -3615, -3615, -3613, -3613, -3611, -3610, -3610, -3608, -3608, -3607, -3605, -3605, -3603, -3604, -3602, -3602, -3600, -3598, -3598, -3596, -3597, -3595, -3594, -3594, -3591, -3592, -3590, -3589, -3589, -3587, -3587, -3584, -3585, -3583, -3582, -3581, -3580, -3579, -3578, -3577, -3577, -3576, -3574, -3573, -3572, -3572, -3571, -3570, -3569, -3566, -3567, -3565, -3564, -3564, -3562, -3563, -3561, -3561, -3559, -3539, -3637, -3114};