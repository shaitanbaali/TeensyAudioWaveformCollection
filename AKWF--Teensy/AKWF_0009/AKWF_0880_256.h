/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0880 256 samples */
 
const int16_t AKWF_0880_256_DATA [256] = 
{3241, 8091, 9742, 11312, 12586, 13697, 14691, 15589, 16415, 17175, 17880, 18537, 19151, 19723, 20261, 20765, 21234, 21673, 22085, 22465, 22821, 23151, 23455, 23734, 23990, 24222, 24432, 24619, 24784, 24928, 25052, 25153, 25235, 25296, 25339, 25361, 25366, 25352, 25318, 25269, 25202, 25115, 25013, 24896, 24761, 24611, 24444, 24263, 24068, 23858, 23633, 23396, 23144, 22880, 22602, 22312, 22010, 21697, 21371, 21034, 20687, 20329, 19960, 19580, 19190, 18792, 18384, 17965, 17537, 17100, 16654, 16199, 15734, 15260, 14777, 14284, 13780, 13268, 12744, 12208, 11658, 11094, 10515, 9917, 9297, 8651, 7969, 7241, 6445, 5502, 4651, 1867, -3284, -4454, -5190, -5721, -6102, -6378, -6565, -6676, -6715, -6684, -6581, -6400, -6129, -5751, -5223, -4485, -3272, 2003, 4714, 5598, 6558, 7379, 8133, 8842, 9520, 10173, 10804, 11421, 12024, 12615, 13196, 13768, 14333, 14890, 15440, 15983, 16523, 17054, 17581, 18104, 18619, 19130, 19638, 20138, 20635, 21127, 21613, 22095, 22573, 23044, 23511, 23972, 24426, 24877, 25324, 25746, 25928, 25907, 25621, 25093, 24400, 23596, 22766, 21989, 21308, 20722, 20210, 19743, 19291, 18829, 18336, 17793, 17189, 16512, 15747, 14881, 13894, 12751, 11402, 9648, 7914, 713, -7952, -9816, -11741, -13296, -14669, -15913, -17065, -18137, -19143, -20096, -21000, -21855, -22673, -23452, -24193, -24901, -25574, -26215, -26826, -27404, -27951, -28469, -28956, -29413, -29842, -30240, -30608, -30949, -31259, -31541, -31792, -32015, -32209, -32373, -32509, -32616, -32695, -32745, -32766, -32760, -32726, -32665, -32576, -32461, -32320, -32151, -31957, -31735, -31492, -31223, -30929, -30609, -30267, -29901, -29514, -29102, -28668, -28212, -27733, -27230, -26708, -26162, -25594, -25003, -24388, -23750, -23088, -22398, -21682, -20938, -20162, -19350, -18502, -17610, -16666, -15665, -14586, -13414, -12113, -10618, -8844, -6111};