/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0803 256 samples */
 
const int16_t AKWF_0803_256_DATA [256] = 
{2244, 9895, 16315, 21607, 25750, 28812, 30885, 32078, 32508, 32284, 31517, 30298, 28713, 26847, 24763, 22520, 20181, 17782, 15365, 12970, 10617, 8331, 6143, 4054, 2083, 245, -1466, -3034, -4457, -5744, -6888, -7889, -8756, -9490, -10098, -10584, -10955, -11217, -11378, -11444, -11425, -11324, -11152, -10914, -10619, -10272, -9880, -9453, -8994, -8508, -8003, -7483, -6952, -6418, -5882, -5348, -4822, -4306, -3799, -3308, -2835, -2382, -1948, -1535, -1146, -780, -439, -121, 170, 437, 681, 901, 1096, 1270, 1420, 1550, 1659, 1748, 1820, 1874, 1911, 1932, 1941, 1936, 1920, 1892, 1855, 1808, 1755, 1695, 1629, 1559, 1484, 1406, 1328, 1243, 1163, 1078, 996, 914, 832, 751, 674, 598, 524, 455, 386, 320, 258, 198, 141, 88, 35, -12, -59, -104, -148, -192, -238, -289, -344, -428, -523, -551, -505, -410, -288, -153, -15, 118, 243, 356, 456, 543, 614, 670, 716, 746, 764, 771, 769, 757, 737, 709, 677, 637, 595, 547, 497, 447, 395, 342, 288, 235, 183, 133, 85, 37, -7, -48, -89, -124, -157, -189, -217, -242, -266, -284, -302, -315, -326, -335, -342, -345, -348, -346, -345, -342, -336, -329, -322, -313, -303, -291, -279, -266, -255, -240, -226, -213, -199, -186, -173, -158, -145, -131, -120, -107, -94, -82, -72, -61, -52, -42, -33, -24, -17, -9, -3, 3, 8, 13, 19, 22, 28, 29, 33, 35, 38, 40, 42, 43, 42, 45, 44, 45, 45, 45, 44, 43, 44, 43, 44, 42, 41, 40, 40, 40, 38, 38, 38, 36, -54, 261, -1847, -15626, -24577, -25818, -28726, -30975, -32576, -32280, -28724, -22407, -14459, -5801};