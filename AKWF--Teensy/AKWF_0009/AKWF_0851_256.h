/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0851 256 samples */
 
const int16_t AKWF_0851_256_DATA [256] = 
{3886, 3889, 3892, 3893, 3895, 3897, 3898, 4181, 2595, 9559, 33698, 32587, 32751, 32763, 32760, 32758, 32753, 32749, 32744, 32740, 32734, 32728, 32723, 32716, 32710, 32703, 32696, 32689, 32682, 32675, 32667, 32660, 32652, 32645, 32636, 32629, 32621, 32613, 32605, 32596, 32588, 32580, 32572, 32563, 32555, 32547, 32538, 32529, 32521, 32433, 32748, 31723, 6293, 2920, 3768, 3599, 3594, 3588, 3583, 3578, 3574, 3570, 3566, 3562, 3559, 3556, 3553, 3550, 3548, 3546, 3543, 3541, 3540, 3537, 3536, 3533, 3531, 3530, 3529, 3527, 3525, 3524, 3523, 3522, 3520, 3519, 3518, 3517, 3515, 3514, 3513, 3512, 3511, 3510, 3508, 3507, 3507, 3506, 3505, 3503, 3502, 3501, 3501, 3500, 3499, 3497, 3496, 3495, 3495, 3494, 3493, 3491, 3491, 3490, 3489, 3488, 3487, 3486, 3475, 3404, 3923, -9554, -13198, -12359, -12508, -12508, -12507, -12505, -12504, -12503, -12502, -12499, -12498, -12496, -12494, -12491, -12489, -12487, -12484, -12481, -12479, -12477, -12474, -12471, -12468, -12464, -12462, -12459, -12456, -12453, -12450, -12447, -12443, -12440, -12438, -12434, -12431, -12428, -12424, -12421, -12418, -12414, -12411, -12409, -12405, -12402, -12399, -12395, -12392, -12389, -12385, -12382, -12378, -12375, -12372, -12369, -12366, -12362, -12359, -12356, -12352, -12349, -12346, -12342, -12340, -12336, -12333, -12329, -12326, -12323, -12319, -12316, -12313, -12309, -12306, -12303, -12299, -12297, -12293, -12290, -12286, -12283, -12280, -12277, -12273, -12270, -12266, -12264, -12260, -12257, -12254, -12250, -12247, -12244, -12240, -12237, -12234, -12230, -12228, -12224, -12220, -12218, -12213, -12211, -12207, -12204, -12201, -12198, -12194, -12192, -12188, -12184, -12182, -12178, -12175, -12172, -12168, -12165, -12162, -12159, -12156, -12152, -12149, -12146, -12142, -12139, -12136, -12132, -12130, -12126, -12122, -12120, -12116, -12113, -12110, -12106};