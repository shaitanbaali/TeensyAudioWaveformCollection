/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0854 256 samples */
 
const int16_t AKWF_0854_256_DATA [256] = 
{484, 1234, 1965, 2696, 3423, 4146, 4869, 5584, 6296, 7004, 7705, 8403, 9095, 9781, 10461, 11137, 11803, 12464, 13118, 13765, 14405, 15036, 15659, 16276, 16882, 17480, 18071, 18652, 19222, 19785, 20337, 20879, 21412, 21934, 22446, 22948, 23438, 23917, 24386, 24842, 25288, 25722, 26144, 26555, 26953, 27339, 27712, 28074, 28422, 28758, 29082, 29391, 29688, 29972, 30242, 30500, 30744, 30974, 31191, 31394, 31583, 31759, 31920, 32067, 32201, 32320, 32425, 32518, 32594, 32658, 32706, 32741, 32760, 32771, 32722, 32549, 32314, 32035, 31720, 31372, 30998, 30597, 30173, 29729, 29264, 28780, 28280, 27761, 27228, 26681, 26118, 25543, 24957, 24357, 23746, 23125, 22493, 21853, 21202, 20542, 19876, 19202, 18518, 17830, 17135, 16432, 15727, 15014, 14296, 13576, 12850, 12120, 11389, 10654, 9914, 9176, 8433, 7689, 6945, 6198, 5452, 4707, 3960, 3214, 2470, 1726, 983, 243, -496, -1231, -1964, -2697, -3424, -4148, -4870, -5585, -6296, -7005, -7707, -8405, -9096, -9781, -10462, -11138, -11803, -12465, -13119, -13765, -14406, -15037, -15660, -16276, -16883, -17480, -18071, -18652, -19223, -19785, -20338, -20880, -21413, -21934, -22446, -22948, -23438, -23917, -24386, -24843, -25288, -25722, -26144, -26555, -26953, -27339, -27712, -28074, -28422, -28758, -29082, -29391, -29688, -29972, -30242, -30500, -30744, -30974, -31191, -31394, -31583, -31759, -31920, -32067, -32201, -32320, -32426, -32518, -32594, -32658, -32706, -32741, -32760, -32771, -32722, -32549, -32314, -32035, -31720, -31372, -30998, -30597, -30173, -29729, -29264, -28780, -28280, -27761, -27228, -26681, -26119, -25544, -24957, -24357, -23746, -23126, -22494, -21853, -21202, -20543, -19877, -19202, -18519, -17831, -17135, -16432, -15727, -15015, -14296, -13576, -12850, -12121, -11390, -10654, -9916, -9177, -8434, -7690, -6946, -6199, -5453, -4708, -3961, -3215, -2471, -1728, -988, -234};