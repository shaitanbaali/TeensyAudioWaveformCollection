/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0830 256 samples */
 
const int16_t AKWF_0830_256_DATA [256] = 
{267, 777, 1252, 1704, 2130, 2530, 2904, 3250, 3571, 3865, 4131, 4372, 4588, 4778, 4946, 5091, 5214, 5318, 5404, 5472, 5527, 5568, 5598, 5617, 5631, 5642, 5647, 5653, 5661, 5671, 5687, 5711, 5746, 5793, 5853, 5927, 6021, 6131, 6262, 6414, 6590, 6789, 7011, 7258, 7533, 7832, 8158, 8509, 8888, 9292, 9721, 10176, 10654, 11157, 11680, 12228, 12795, 13382, 13987, 14609, 15246, 15898, 16559, 17234, 17919, 18608, 19305, 20007, 20711, 21414, 22117, 22817, 23513, 24202, 24880, 25549, 26204, 26843, 27465, 28067, 28644, 29198, 29723, 30216, 30677, 31099, 31481, 31821, 32114, 32355, 32546, 32679, 32752, 32763, 32709, 32587, 32393, 32129, 31789, 31371, 30880, 30310, 29659, 28934, 28132, 27253, 26305, 25284, 24195, 23045, 21833, 20566, 19252, 17891, 16488, 15057, 13594, 12110, 10614, 9105, 7594, 6088, 4588, 3102, 1638, 195, -1216, -2595, -3941, -5240, -6498, -7712, -8875, -9987, -11049, -12053, -13002, -13898, -14735, -15518, -16242, -16907, -17518, -18074, -18571, -19016, -19407, -19744, -20031, -20267, -20453, -20594, -20688, -20740, -20748, -20718, -20650, -20548, -20413, -20249, -20055, -19838, -19599, -19341, -19068, -18781, -18484, -18181, -17873, -17564, -17256, -16954, -16659, -16374, -16100, -15842, -15600, -15375, -15172, -14991, -14832, -14695, -14585, -14500, -14439, -14407, -14399, -14414, -14456, -14521, -14609, -14718, -14848, -14996, -15161, -15342, -15534, -15738, -15953, -16172, -16396, -16623, -16849, -17071, -17290, -17501, -17701, -17891, -18067, -18226, -18367, -18487, -18586, -18659, -18708, -18731, -18726, -18690, -18625, -18528, -18401, -18241, -18048, -17823, -17565, -17275, -16953, -16599, -16215, -15802, -15359, -14890, -14393, -13872, -13329, -12763, -12178, -11576, -10959, -10328, -9686, -9035, -8376, -7718, -7053, -6388, -5730, -5073, -4423, -3784, -3155, -2541, -1941, -1357, -793, -242};