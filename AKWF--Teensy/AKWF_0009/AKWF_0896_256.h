/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0896 256 samples */
 
const int16_t AKWF_0896_256_DATA [256] = 
{1107, 2901, 4555, 6199, 7744, 9188, 10579, 11972, 13407, 14869, 16283, 17559, 18595, 19340, 19831, 20171, 20530, 21092, 21999, 23308, 24976, 26849, 28715, 30361, 31615, 32398, 32737, 32738, 32552, 32318, 32128, 31994, 31858, 31625, 31204, 30552, 29693, 28723, 27774, 26991, 26462, 26209, 26174, 26243, 26284, 26194, 25934, 25544, 25128, 24809, 24694, 24817, 25133, 25512, 25781, 25777, 25395, 24624, 23553, 22359, 21239, 20370, 19855, 19704, 19824, 20072, 20286, 20341, 20175, 19802, 19281, 18698, 18108, 17518, 16882, 16114, 15131, 13898, 12439, 10873, 9375, 8133, 7303, 6955, 7053, 7456, 7964, 8358, 8470, 8213, 7608, 6757, 5811, 4907, 4139, 3521, 2991, 2453, 1804, 989, 20, -1021, -2007, -2802, -3317, -3533, -3503, -3348, -3204, -3179, -3324, -3607, -3934, -4182, -4246, -4087, -3745, -3345, -3056, -3043, -3412, -4179, -5256, -6469, -7616, -8513, -9051, -9210, -9075, -8785, -8509, -8371, -8443, -8718, -9137, -9621, -10111, -10597, -11123, -11777, -12645, -13772, -15140, -16638, -18098, -19340, -20199, -20603, -20581, -20264, -19850, -19555, -19549, -19917, -20640, -21613, -22679, -23690, -24540, -25202, -25724, -26192, -26705, -27317, -28010, -28702, -29259, -29543, -29449, -28948, -28088, -26981, -25761, -24547, -23390, -22270, -21107, -19782, -18195, -16318, -14185, -11933, -9742, -7782, -6181, -4973, -4081, -3354, -2595, -1627, -345, 1265, 3128, 5082, 6966, 8638, 10018, 11103, 11951, 12639, 13228, 13737, 14124, 14310, 14213, 13783, 13042, 12091, 11102, 10260, 9729, 9597, 9843, 10341, 10897, 11303, 11382, 11043, 10298, 9246, 8045, 6839, 5740, 4779, 3905, 3031, 2056, 916, -379, -1751, -3076, -4206, -5037, -5530, -5720, -5716, -5645, -5621, -5697, -5854, -6002, -6021, -5800, -5290, -4520, -3605, -2713, -2007, -1610, -1546, -1742, -2039, -2232, -2141, -1607, -803};