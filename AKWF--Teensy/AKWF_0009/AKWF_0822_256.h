/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0822 256 samples */
 
const int16_t AKWF_0822_256_DATA [256] = 
{532, 2060, 3443, 4715, 5865, 6891, 7793, 8566, 9222, 9773, 10237, 10641, 11014, 11370, 11734, 12121, 12538, 12989, 13475, 13988, 14524, 15071, 15619, 16163, 16690, 17200, 17700, 18190, 18683, 19188, 19706, 20239, 20789, 21348, 21912, 22474, 23028, 23561, 24067, 24536, 24964, 25358, 25718, 26053, 26374, 26686, 26998, 27315, 27631, 27950, 28265, 28571, 28860, 29120, 29341, 29515, 29627, 29666, 29630, 29510, 29306, 29007, 28614, 28119, 27520, 26814, 26000, 25072, 24034, 22880, 21609, 20228, 18741, 17164, 15525, 13846, 12158, 10499, 8879, 7317, 5832, 4416, 3073, 1799, 586, -576, -1694, -2781, -3838, -4867, -5863, -6816, -7723, -8577, -9374, -10115, -10803, -11437, -12030, -12585, -13110, -13613, -14104, -14584, -15048, -15492, -15898, -16245, -16517, -16694, -16763, -16717, -16548, -16255, -15839, -15303, -14652, -13894, -13045, -12119, -11133, -10111, -9065, -8025, -7012, -6042, -5136, -4311, -3581, -2956, -2441, -2041, -1762, -1603, -1563, -1641, -1829, -2110, -2466, -2865, -3284, -3702, -4094, -4449, -4759, -5013, -5216, -5373, -5491, -5577, -5644, -5701, -5755, -5807, -5855, -5894, -5912, -5903, -5864, -5792, -5689, -5558, -5407, -5243, -5071, -4903, -4752, -4623, -4521, -4443, -4385, -4341, -4298, -4253, -4196, -4122, -4037, -3937, -3833, -3724, -3621, -3532, -3467, -3432, -3434, -3486, -3587, -3749, -3974, -4268, -4634, -5083, -5618, -6240, -6958, -7775, -8688, -9706, -10831, -12060, -13385, -14794, -16257, -17752, -19244, -20692, -22078, -23380, -24575, -25666, -26651, -27536, -28328, -29038, -29677, -30259, -30792, -31271, -31694, -32056, -32348, -32563, -32702, -32763, -32754, -32679, -32547, -32365, -32147, -31900, -31633, -31351, -31049, -30721, -30347, -29906, -29380, -28749, -27996, -27117, -26109, -24967, -23696, -22305, -20791, -19173, -17468, -15681, -13842, -11971, -10075, -8187, -6325, -4501, -2741, -1024};