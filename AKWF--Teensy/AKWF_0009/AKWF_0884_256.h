/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0884 256 samples */
 
const int16_t AKWF_0884_256_DATA [256] = 
{4621, 11782, 17345, 21671, 24960, 27432, 29278, 30642, 31651, 32392, 32562, 31002, 26748, 19836, 11174, 2210, -5897, -12685, -18081, -22233, -25390, -27755, -29513, -30821, -31784, -32492, -32719, -31436, -27583, -21010, -12546, -3570, 4727, 11719, 17316, 21660, 24951, 27425, 29273, 30639, 31649, 32382, 32508, 30887, 26583, 19647, 10996, 2061, -6015, -12777, -18150, -22285, -25428, -27784, -29534, -30836, -31795, -32502, -32725, -31436, -27576, -20996, -12527, -3548, 4748, 11736, 17328, 21670, 24959, 27430, 29278, 30642, 31651, 32385, 32513, 30894, 26593, 19663, 11016, 2082, -5995, -12759, -18135, -22274, -25421, -27778, -29530, -30833, -31792, -32501, -32747, -31476, -27616, -21019, -12524, -3528, 4775, 11763, 17352, 21689, 24974, 27443, 29286, 30648, 31656, 32387, 32511, 30890, 26585, 19649, 10997, 2062, -6015, -12776, -18150, -22285, -25428, -27784, -29534, -30836, -31794, -32505, -32694, -31261, -27209, -20456, -11900, -2940, 5277, 12167, 17665, 21927, 25153, 27576, 29385, 30722, 31710, 32429, 32545, 30917, 26611, 19675, 11025, 2089, -5990, -12755, -18133, -22272, -25419, -27777, -29529, -30832, -31792, -32501, -32747, -31476, -27616, -21019, -12524, -3528, 4775, 11763, 17352, 21689, 24974, 27443, 29286, 30649, 31656, 32394, 32570, 31066, 26917, 20114, 11528, 2580, -5560, -12404, -17857, -22061, -25260, -27657, -29440, -30766, -31742, -32467, -32666, -31239, -27193, -20445, -11891, -2933, 5281, 12170, 17668, 21929, 25155, 27577, 29386, 30722, 31710, 32434, 32587, 31014, 26753, 19838, 11178, 2215, -5892, -12680, -18077, -22230, -25389, -27754, -29512, -30820, -31783, -32491, -32709, -31409, -27548, -20975, -12520, -3556, 4733, 11720, 17315, 21659, 24950, 27424, 29271, 30637, 31650, 32375, 32476, 30912, 26774, 20038, 11552, 2679, -5435, -12282, -17753, -21977, -25194, -27608, -29403, -30737, -31725, -32424, -32540, -31142, -27288, -20832, -12549, -3580};