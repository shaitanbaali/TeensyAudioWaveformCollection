/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0865 256 samples */
 
const int16_t AKWF_0865_256_DATA [256] = 
{852, 1989, 2977, 3999, 5102, 6287, 7574, 9014, 10623, 12388, 14302, 16345, 18482, 20718, 22940, 24403, 24706, 24478, 24211, 23523, 22003, 20002, 17972, 15906, 13737, 11550, 9302, 6879, 4288, 1652, -961, -3594, -6233, -8831, -11350, -13787, -16090, -18261, -20290, -22172, -23914, -25498, -26919, -28176, -29271, -30206, -31033, -31694, -32193, -32531, -32716, -32767, -32676, -32428, -32045, -31522, -30860, -30078, -29162, -28156, -27015, -25766, -24387, -22892, -21264, -19445, -17368, -15020, -12441, -9689, -6871, -4116, -1439, 1120, 3504, 5674, 7643, 9414, 11058, 12542, 13866, 15047, 16081, 16932, 17639, 18197, 18584, 18820, 18884, 18745, 18443, 18004, 17462, 16804, 16075, 15248, 14309, 13256, 12140, 10986, 9755, 8422, 6977, 5426, 3772, 2075, 340, -1423, -3164, -4883, -6547, -8171, -9717, -11195, -12590, -13910, -15158, -16303, -17300, -18182, -18982, -19733, -20440, -21088, -21672, -22174, -22618, -22961, -23222, -23409, -23498, -23481, -23360, -23133, -22799, -22374, -21825, -21187, -20453, -19613, -18676, -17639, -16519, -15295, -14006, -12715, -11530, -10446, -9383, -8313, -7238, -6148, -5082, -4032, -3005, -2013, -1069, -239, 389, 710, 808, 799, 723, 604, 454, 335, 249, 219, 241, 318, 429, 585, 770, 989, 1227, 1447, 1626, 1766, 1911, 2060, 2193, 2322, 2435, 2541, 2615, 2660, 2691, 2687, 2654, 2606, 2510, 2388, 2239, 2053, 1846, 1600, 1345, 1052, 734, 364, -74, -623, -1297, -2066, -2880, -3722, -4577, -5438, -6296, -7170, -8103, -9085, -10067, -11034, -11988, -12914, -13817, -14683, -15544, -16368, -17134, -17847, -18567, -19275, -19905, -20436, -20890, -21224, -21482, -21693, -21881, -21981, -21950, -21789, -21491, -21062, -20493, -19831, -19037, -18083, -16971, -15737, -14418, -13014, -11457, -9990, -9028, -8400, -7753, -6971, -6123, -5197, -4136, -2973, -1732, -383};