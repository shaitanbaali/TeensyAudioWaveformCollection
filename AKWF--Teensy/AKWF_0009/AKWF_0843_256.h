/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0843 256 samples */
 
const int16_t AKWF_0843_256_DATA [256] = 
{1131, 3051, 4911, 6749, 8554, 10326, 12058, 13741, 15378, 16963, 18486, 19951, 21352, 22681, 23942, 25129, 26236, 27267, 28214, 29075, 29852, 30539, 31136, 31643, 32056, 32375, 32598, 32737, 32727, 32254, 31490, 30568, 29513, 28354, 27101, 25767, 24368, 22906, 21388, 19829, 18229, 16592, 14934, 13248, 11544, 9834, 8111, 6386, 4667, 2951, 1247, -439, -2110, -3757, -5373, -6963, -8517, -10030, -11505, -12933, -14311, -15641, -16916, -18132, -19291, -20386, -21417, -22383, -23277, -24101, -24855, -25532, -26134, -26660, -27107, -27476, -27764, -27971, -28100, -28139, -27778, -27082, -26229, -25248, -24160, -22987, -21744, -20435, -19076, -17676, -16238, -14774, -13292, -11793, -10290, -8787, -7288, -5804, -4337, -2892, -1477, -97, 1246, 2543, 3794, 4993, 6132, 7213, 8229, 9175, 10052, 10855, 11580, 12227, 12792, 13273, 13671, 13982, 14203, 14341, 14374, 13980, 13248, 12360, 11346, 10231, 9042, 7795, 6503, 5185, 3850, 2509, 1179, -133, -1416, -2657, -3851, -4986, -6052, -7045, -7957, -8778, -9506, -10135, -10659, -11077, -11383, -11575, -11660, -11347, -10654, -9791, -8791, -7684, -6483, -5208, -3872, -2477, -1042, 427, 1927, 3442, 4970, 6506, 8035, 9556, 11065, 12548, 14006, 15433, 16817, 18159, 19454, 20691, 21873, 22992, 24041, 25023, 25929, 26757, 27506, 28171, 28750, 29243, 29646, 29957, 30175, 30313, 30295, 29757, 28887, 27839, 26640, 25322, 23901, 22389, 20805, 19152, 17441, 15685, 13886, 12052, 10197, 8318, 6425, 4530, 2631, 735, -1143, -3012, -4859, -6673, -8461, -10212, -11918, -13581, -15194, -16748, -18249, -19684, -21051, -22352, -23578, -24727, -25800, -26788, -27692, -28511, -29240, -29878, -30426, -30879, -31237, -31500, -31666, -31747, -31409, -30621, -29633, -28483, -27207, -25817, -24333, -22772, -21136, -19440, -17694, -15898, -14067, -12208, -10319, -8416, -6504, -4583, -2668, -722};