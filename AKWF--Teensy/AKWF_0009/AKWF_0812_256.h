/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0812 256 samples */
 
const int16_t AKWF_0812_256_DATA [256] = 
{2586, 8648, 13410, 17062, 19659, 21307, 22130, 22251, 21797, 20882, 19613, 18078, 16354, 14518, 12616, 10698, 8809, 6968, 5206, 3543, 1985, 546, -766, -1955, -3015, -3948, -4761, -5452, -6029, -6500, -6867, -7139, -7323, -7425, -7454, -7415, -7314, -7162, -6960, -6718, -6441, -6133, -5803, -5454, -5088, -4714, -4332, -3948, -3565, -3185, -2812, -2448, -2093, -1751, -1424, -1112, -816, -537, -277, -35, 188, 394, 581, 750, 900, 1033, 1149, 1248, 1332, 1400, 1454, 1494, 1522, 1538, 1543, 1538, 1523, 1500, 1470, 1433, 1390, 1341, 1289, 1233, 1173, 1112, 1048, 983, 919, 852, 787, 723, 660, 597, 537, 479, 422, 368, 317, 268, 221, 178, 137, 100, 65, 33, 3, -23, -46, -68, -86, -102, -116, -128, -137, -145, -150, -154, -156, -158, -157, -156, -154, -150, -145, -141, -135, -129, -121, -114, -107, -100, -92, -84, -77, -69, -61, -54, -47, -40, -33, -26, -21, -15, -10, -5, 0, 3, 7, 11, 14, 17, 20, 22, 24, 25, 26, 28, 28, 29, 28, 29, 28, 29, 28, 28, 27, 25, 25, 24, 23, 22, 20, 19, 18, 17, 16, 15, 13, 12, 11, 10, 9, 8, 7, 6, 5, 4, 3, 2, 1, 1, 1, 0, -1, 0, -1, -2, -1, -2, -3, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -3, -2, -2, -2, -2, -1, -2, -1, -1, 0, -1, 0, 0, 0, -1, -1, 0, 1, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, -19, -108, 395, -8659, -24908, -32324, -31929, -27018, -19865, -11982, -4179};