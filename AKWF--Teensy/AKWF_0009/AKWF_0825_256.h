/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0825 256 samples */
 
const int16_t AKWF_0825_256_DATA [256] = 
{929, 2182, 3561, 5075, 6655, 8282, 9940, 11602, 13251, 14865, 16419, 17909, 19328, 20667, 21934, 23126, 24242, 25291, 26270, 27175, 28010, 28769, 29451, 30062, 30598, 31062, 31461, 31794, 32069, 32291, 32465, 32595, 32687, 32743, 32767, 32760, 32725, 32663, 32577, 32467, 32335, 32181, 32007, 31815, 31603, 31377, 31132, 30872, 30600, 30313, 30015, 29705, 29402, 29171, 29029, 28939, 28882, 28838, 28800, 28763, 28724, 28690, 28034, 27094, 26432, 25943, 25245, 24373, 23391, 22317, 21165, 19961, 18725, 17483, 16259, 15062, 13904, 12792, 11721, 10692, 9700, 8659, 7514, 6302, 5051, 3785, 2516, 1241, -29, -1293, -2552, -3795, -5019, -6221, -7391, -8525, -9622, -10672, -11678, -12641, -13555, -14426, -15256, -16040, -16783, -17483, -18133, -18736, -19284, -19772, -20200, -20562, -20855, -21080, -21241, -21343, -21380, -21309, -21095, -20749, -20305, -19794, -19238, -18657, -18062, -17461, -16863, -16269, -15683, -15109, -14547, -13998, -13465, -12949, -12451, -11974, -11518, -11085, -10679, -10298, -9946, -9622, -9327, -9058, -8824, -8684, -8664, -8727, -8843, -8993, -9163, -9346, -9535, -9726, -9918, -10109, -10297, -10483, -10662, -10838, -11009, -11174, -11333, -11487, -11634, -11775, -11910, -12037, -12157, -12268, -12369, -12457, -12531, -12587, -12621, -12632, -12621, -12586, -12529, -12450, -12353, -12244, -12130, -12014, -11902, -11795, -11694, -11601, -11515, -11435, -11357, -11279, -11198, -11113, -11020, -10919, -10809, -10690, -10562, -10425, -10278, -10123, -9961, -9789, -9611, -9427, -9236, -9038, -8844, -8698, -8652, -8708, -8846, -9040, -9275, -9537, -9816, -10107, -10407, -10712, -11018, -11326, -11633, -11937, -12235, -12522, -12796, -13050, -13281, -13483, -13651, -13779, -13865, -13906, -13897, -13842, -13735, -13582, -13382, -13137, -12849, -12519, -12150, -11746, -11295, -10723, -9998, -9170, -8283, -7369, -6441, -5513, -4596, -3705, -2218, -463};