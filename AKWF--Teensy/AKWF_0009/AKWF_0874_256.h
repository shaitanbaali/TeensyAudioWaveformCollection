/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0874 256 samples */
 
const int16_t AKWF_0874_256_DATA [256] = 
{324, 1071, 1821, 2591, 3377, 4183, 5009, 5852, 6715, 7600, 8503, 9430, 10380, 11350, 12347, 13368, 14410, 15479, 16572, 17681, 18806, 19939, 21071, 22201, 23316, 24406, 25468, 26488, 27458, 28373, 29220, 29993, 30685, 31287, 31793, 32200, 32500, 32690, 32766, 32728, 32573, 32299, 31908, 31402, 30779, 30048, 29207, 28262, 27221, 26084, 24860, 23560, 22184, 20742, 19248, 17700, 16112, 14496, 12850, 11193, 9530, 7866, 6214, 4579, 2967, 1391, -144, -1637, -3075, -4457, -5779, -7029, -8210, -9317, -10345, -11295, -12164, -12947, -13650, -14269, -14803, -15257, -15629, -15922, -16139, -16280, -16351, -16352, -16289, -16165, -15983, -15749, -15466, -15137, -14769, -14366, -13930, -13469, -12985, -12482, -11967, -11442, -10909, -10375, -9842, -9313, -8793, -8283, -7784, -7303, -6838, -6392, -5968, -5565, -5185, -4830, -4499, -4192, -3910, -3654, -3422, -3213, -3028, -2865, -2722, -2601, -2497, -2413, -2344, -2291, -2250, -2220, -2202, -2192, -2189, -2192, -2199, -2209, -2221, -2233, -2243, -2252, -2258, -2261, -2259, -2253, -2240, -2221, -2196, -2166, -2128, -2086, -2036, -1981, -1920, -1855, -1786, -1713, -1637, -1560, -1482, -1404, -1326, -1250, -1178, -1110, -1047, -990, -940, -899, -866, -845, -834, -834, -848, -876, -917, -974, -1045, -1132, -1236, -1357, -1492, -1644, -1813, -1998, -2200, -2417, -2649, -2895, -3156, -3431, -3718, -4017, -4325, -4644, -4972, -5307, -5648, -5994, -6344, -6696, -7049, -7401, -7752, -8098, -8440, -8775, -9101, -9419, -9727, -10021, -10303, -10569, -10819, -11051, -11264, -11458, -11631, -11782, -11909, -12013, -12092, -12146, -12174, -12176, -12150, -12098, -12018, -11911, -11775, -11613, -11423, -11205, -10960, -10687, -10388, -10063, -9712, -9336, -8937, -8512, -8063, -7594, -7101, -6586, -6052, -5496, -4922, -4328, -3714, -3083, -2435, -1769, -1088, -375};