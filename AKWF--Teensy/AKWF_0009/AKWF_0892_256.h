/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0892 256 samples */
 
const int16_t AKWF_0892_256_DATA [256] = 
{-26696, -4764, 1041, -4687, -6729, -7076, -6629, -5914, -5184, -4546, -4044, -3675, -3426, -3279, -3215, -3207, -3237, -3287, -3339, -3381, -3400, -3387, -3337, -3245, -3109, -2930, -2709, -2450, -2160, -1842, -1504, -1154, -799, -448, -104, 222, 525, 800, 1044, 1250, 1420, 1550, 1640, 1691, 1706, 1685, 1633, 1553, 1449, 1328, 1191, 1045, 895, 744, 599, 460, 332, 221, 125, 47, -12, -50, -70, -70, -53, -18, 30, 90, 161, 239, 323, 407, 493, 576, 655, 727, 792, 847, 893, 929, 953, 967, 970, 963, 946, 922, 891, 854, 812, 768, 722, 676, 631, 587, 548, 512, 480, 455, 434, 420, 411, 408, 411, 419, 431, 448, 467, 489, 513, 537, 562, 587, 610, 631, 652, 669, 683, 694, 702, 707, 709, 708, 704, 698, 689, 679, 667, 653, 640, 626, 613, 600, 587, 576, 566, 558, 551, 547, 543, 542, 541, 544, 547, 551, 556, 562, 569, 576, 583, 590, 597, 604, 610, 615, 620, 623, 626, 627, 628, 628, 627, 626, 623, 620, 616, 612, 608, 604, 599, 595, 592, 588, 585, 582, 580, 578, 576, 576, 575, 576, 575, 577, 578, 580, 581, 584, 585, 588, 589, 591, 593, 594, 595, 596, 598, 597, 598, 597, 598, 597, 596, 595, 594, 593, 592, 591, 590, 588, 587, 585, 584, 583, 583, 582, 581, 582, 581, 580, 581, 582, 581, 582, 582, 583, 583, 584, 584, 584, 585, 585, 586, 585, 586, 586, 586, 585, 586, 585, 585, 584, 585, 584, 584, 583, 582, 582, 581, 581, 581, 579, 580, 580, 579, 579, 578, 579};