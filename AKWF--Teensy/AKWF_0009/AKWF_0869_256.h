/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0869 256 samples */
 
const int16_t AKWF_0869_256_DATA [256] = 
{939, 4177, 7275, 10313, 13280, 16182, 19019, 21783, 24482, 26940, 30402, 29408, 2138, -1008, -2236, -5077, -1525, 5521, 2808, 1453, -39, -1472, -2470, -5950, 2708, 23064, 13764, 7402, 841, -5489, -11859, -16137, -17033, -17910, -18777, -19619, -20444, -21256, -22062, -22861, -23659, -24454, -25252, -26002, -27049, -25622, -21711, -18241, -14886, -11675, -8617, -5717, -2956, -345, 2115, 4443, 6629, 8676, 10594, 12381, 14038, 15578, 16996, 18299, 19489, 20572, 21552, 22433, 23219, 23914, 24522, 25038, 25514, 25772, 24175, 22119, 20168, 18218, 16282, 14363, 12475, 10606, 8767, 6963, 5188, 3450, 1754, 93, -1523, -3092, -4622, -6099, -7526, -8904, -10229, -11498, -12712, -13872, -14975, -16020, -17007, -17936, -18805, -19612, -20361, -21053, -21671, -22277, -22636, -20897, -18705, -16504, -14721, -22506, -21681, -19077, -16919, -14715, -12538, -10374, -8235, -6119, -4017, -1938, 117, 2159, 4179, 6178, 8163, 10125, 12068, 13998, 15901, 17787, 19659, 21506, 23337, 25151, 26941, 28679, 30577, 31606, 28740, 25576, 22657, 19834, 17139, 14574, 12118, 9781, 7558, 5437, 3421, 1508, -317, -2044, -3684, -5247, -6728, -8134, -9471, -10739, -11945, -13094, -14185, -15227, -16223, -17173, -18055, -19059, -18717, -16972, -15426, -13912, -12449, -11039, -9691, -8396, -7158, -5984, -4865, -3806, -2810, -1870, -993, -175, 586, 1287, 1931, 2519, 3050, 3524, 3947, 4316, 4634, 4904, 5124, 5298, 5426, 5512, 5556, 5562, 5530, 5463, 5363, 5231, 5072, 4884, 4674, 4441, 4187, 3915, 3628, 3328, 3016, 2695, 2368, 2038, 1703, 1368, 1035, 704, 379, 62, -248, -543, -828, -1101, -1358, -1599, -1821, -2025, -2207, -2374, -2509, -2622, -4652, -7410, -9882, -12439, -14389, -4545, -5000, -7559, -9504, -11433, -13254, -14873, -17400, -316, 6268, 3815, 6560, 9065, 11797, 459};