/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0804 256 samples */
 
const int16_t AKWF_0804_256_DATA [256] = 
{1003, 3104, 5058, 6906, 8636, 10235, 11698, 13023, 13949, 12961, 8827, 3632, 1244, 2642, 5163, 5886, 4428, 2541, 1757, 2347, 3725, 5258, 6674, 8043, 9532, 11218, 13061, 14940, 16764, 18491, 20091, 21554, 22860, 23970, 24859, 25510, 25912, 26069, 25979, 25653, 25092, 24310, 23322, 22143, 20789, 19287, 17648, 15896, 14056, 12141, 10176, 8184, 6175, 4173, 2202, 264, -1617, -3427, -5162, -6801, -8338, -9770, -11084, -12275, -13345, -14285, -15099, -15782, -16337, -16764, -17071, -17255, -17325, -17285, -17140, -16897, -16561, -16142, -15645, -15076, -14447, -13762, -13029, -12257, -11453, -10621, -9774, -8911, -8040, -7174, -6168, -4326, -793, 4384, 9572, 12689, 13240, 12795, 13188, 14797, 16623, 17561, 17284, 16144, 14629, 12998, 11264, 9318, 7119, 4715, 2192, -356, -2860, -5299, -7636, -9834, -11867, -13698, -15296, -16656, -17764, -18617, -19216, -19563, -19668, -19534, -19179, -18618, -17863, -16936, -15855, -14634, -13301, -11872, -10361, -8799, -7193, -5565, -3936, -2316, -720, 829, 2332, 3771, 5132, 6415, 7609, 8703, 9702, 10594, 11379, 12058, 12629, 13092, 13448, 13702, 13854, 13911, 13868, 13732, 13535, 12007, 6992, -65, -4550, -4456, -2383, -1911, -4014, -6831, -8478, -8507, -7499, -6195, -4945, -3706, -2288, -582, 1371, 3447, 5543, 7592, 9566, 11456, 13229, 14847, 16279, 17495, 18481, 19232, 19747, 20027, 20072, 19891, 19494, 18891, 18100, 17136, 16015, 14762, 13386, 11912, 10363, 8749, 7095, 5427, 3755, 2607, 3447, 6903, 10707, 11651, 9287, 6130, 4640, 4953, 5510, 4996, 3233, 773, -1806, -4272, -6675, -9158, -11790, -14494, -17173, -19742, -22139, -24349, -26360, -28135, -29651, -30880, -31805, -32423, -32733, -32742, -32460, -31892, -31061, -29975, -28659, -27139, -25427, -23555, -21548, -19423, -17211, -14936, -12612, -10271, -7935, -5617, -3345, -1088};