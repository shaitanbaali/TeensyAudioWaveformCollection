/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0883 256 samples */
 
const int16_t AKWF_0883_256_DATA [256] = 
{1978, 6039, 9715, 13167, 16430, 19480, 22240, 24611, 26558, 28098, 29279, 30176, 30848, 31348, 31719, 31995, 32198, 32348, 32458, 32540, 32601, 32645, 32678, 32702, 32720, 32733, 32744, 32750, 32756, 32759, 32762, 32765, 32766, 32767, 32765, 32692, 32429, 31872, 30969, 29754, 28303, 26709, 25052, 23376, 21715, 20085, 18481, 16897, 15329, 13715, 11891, 9758, 7336, 4788, 2347, 189, -1562, -2847, -3572, -3638, -3084, -2059, -791, 517, 1760, 2905, 3971, 4990, 5980, 6961, 7933, 8893, 9840, 10768, 11666, 12527, 13333, 14069, 14731, 15315, 15820, 16256, 16625, 16930, 17175, 17358, 17482, 17543, 17542, 17468, 17297, 16982, 16464, 15574, 13973, 11475, 8116, 4183, 37, -4046, -7898, -11480, -14798, -17863, -20676, -23189, -25338, -27106, -28506, -29582, -30401, -31014, -31470, -31810, -32061, -32247, -32384, -32485, -32560, -32614, -32655, -32646, -32502, -32135, -31493, -30575, -29425, -28090, -26600, -24971, -23196, -21181, -18647, -15402, -11472, -7113, -2656, 1620, 5556, 9121, 12309, 15134, 17648, 19879, 21859, 23629, 25209, 26616, 27858, 28927, 29813, 30515, 31020, 31315, 31381, 31197, 30739, 29987, 28933, 27571, 25894, 23885, 21290, 17898, 13741, 9042, 4185, -471, -4755, -8592, -11970, -14945, -17569, -19894, -21994, -23907, -25631, -27152, -28439, -29481, -30300, -30928, -31401, -31756, -32021, -32216, -32361, -32468, -32548, -32606, -32648, -32680, -32703, -32696, -32619, -32429, -32099, -31624, -31017, -30306, -29507, -28642, -27731, -26787, -25830, -24880, -23944, -23029, -22136, -21258, -20393, -19540, -18692, -17852, -17020, -16190, -15369, -14567, -13815, -13172, -12707, -12484, -12550, -12916, -13567, -14463, -15550, -16776, -18083, -19429, -20774, -22074, -23301, -24422, -25408, -26248, -26931, -27457, -27830, -28049, -28117, -28036, -27810, -27442, -26932, -26280, -25479, -24509, -23346, -21960, -20240, -17900, -14784, -10942, -6647, -2164};