/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0821 256 samples */
 
const int16_t AKWF_0821_256_DATA [256] = 
{344, 1263, 2131, 2971, 3781, 4558, 5305, 6015, 6692, 7335, 7942, 8514, 9053, 9555, 10025, 10462, 10866, 11241, 11588, 11909, 12208, 12486, 12746, 12997, 13234, 13462, 13683, 13902, 14117, 14333, 14549, 14767, 14989, 15214, 15443, 15675, 15910, 16148, 16390, 16633, 16877, 17123, 17367, 17610, 17848, 18083, 18310, 18534, 18748, 18956, 19155, 19349, 19536, 19715, 19883, 20040, 20187, 20320, 20437, 20543, 20638, 20719, 20789, 20849, 20901, 20946, 20983, 21014, 21039, 21058, 21072, 21080, 21083, 21083, 21073, 21055, 21030, 20994, 20944, 20877, 20791, 20684, 20556, 20408, 20238, 20051, 19847, 19629, 19401, 19166, 18922, 18673, 18424, 18173, 17924, 17673, 17426, 17184, 16944, 16706, 16470, 16240, 16011, 15785, 15559, 15333, 15108, 14879, 14649, 14417, 14181, 13940, 13693, 13439, 13177, 12908, 12631, 12345, 12047, 11736, 11412, 11072, 10713, 10336, 9930, 9496, 9032, 8537, 8007, 7446, 6855, 6233, 5583, 4904, 4201, 3474, 2720, 1943, 1147, 329, -510, -1366, -2242, -3134, -4040, -4959, -5888, -6821, -7762, -8702, -9639, -10572, -11495, -12402, -13295, -14168, -15020, -15851, -16655, -17434, -18188, -18911, -19609, -20279, -20920, -21536, -22127, -22693, -23236, -23758, -24259, -24743, -25209, -25659, -26094, -26516, -26925, -27320, -27704, -28074, -28431, -28772, -29100, -29414, -29709, -29990, -30254, -30503, -30734, -30949, -31148, -31333, -31503, -31660, -31803, -31934, -32054, -32160, -32258, -32349, -32432, -32507, -32575, -32635, -32686, -32729, -32757, -32767, -32760, -32734, -32687, -32622, -32534, -32421, -32284, -32122, -31934, -31713, -31458, -31167, -30837, -30465, -30053, -29598, -29099, -28562, -27984, -27366, -26713, -26024, -25302, -24548, -23761, -22941, -22092, -21210, -20295, -19351, -18375, -17373, -16349, -15303, -14240, -13166, -12079, -10989, -9900, -8809, -7726, -6654, -5591, -4547, -3522, -2515, -1534, -561};