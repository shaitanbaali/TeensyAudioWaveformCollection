/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0866 256 samples */
 
const int16_t AKWF_0866_256_DATA [256] = 
{1790, 4723, 7792, 11053, 14488, 18106, 21891, 25719, 30307, 31231, 25919, 21354, 17163, 13373, 9957, 6915, 4229, 1877, -161, -1885, -3336, -4516, -5443, -6139, -6623, -6912, -7018, -6968, -6772, -6454, -6027, -5510, -4913, -4268, -3577, -2856, -2133, -1408, -698, -29, 593, 1154, 1645, 2050, 2365, 2570, 2654, 2621, 2448, 2130, 1667, 1040, 252, -702, -1826, -3138, -4627, -6301, -8162, -10213, -12445, -14875, -17490, -20285, -23189, -26778, -24649, -18303, -13076, -8189, -3739, 258, 3844, 7016, 9790, 12182, 14214, 15889, 17227, 18255, 18972, 19406, 19570, 19485, 19166, 18629, 17898, 16978, 15896, 14674, 13315, 11846, 10287, 8642, 6942, 5196, 3418, 1631, -155, -1923, -3654, -5354, -6996, -8550, -10023, -11398, -12668, -13817, -14839, -15716, -16451, -17030, -17440, -17687, -17754, -17637, -17333, -16841, -16152, -15260, -14168, -12876, -11380, -9682, -7783, -5677, -3375, -875, 1827, 4714, 7790, 11055, 14491, 18108, 21893, 25720, 30309, 31232, 25920, 21354, 17164, 13374, 9957, 6915, 4229, 1876, -162, -1886, -3337, -4518, -5444, -6140, -6625, -6914, -7019, -6970, -6774, -6456, -6029, -5512, -4917, -4270, -3580, -2859, -2137, -1412, -702, -33, 589, 1150, 1641, 2045, 2361, 2566, 2649, 2616, 2443, 2125, 1661, 1035, 247, -708, -1832, -3144, -4633, -6307, -8168, -10219, -12451, -14881, -17496, -20292, -23195, -26784, -24656, -18309, -13083, -8197, -3745, 251, 3838, 7010, 9783, 12176, 14207, 15882, 17221, 18249, 18965, 19399, 19563, 19478, 19159, 18623, 17891, 16971, 15890, 14668, 13307, 11839, 10280, 8635, 6935, 5188, 3411, 1626, -161, -1929, -3660, -5361, -7002, -8556, -10028, -11404, -12673, -13822, -14844, -15721, -16457, -17035, -17445, -17692, -17759, -17641, -17338, -16844, -16155, -15264, -14172, -12878, -11383, -9685, -7785, -5684, -3391, -838};