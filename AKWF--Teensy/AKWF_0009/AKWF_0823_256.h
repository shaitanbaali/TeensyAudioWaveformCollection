/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0823 256 samples */
 
const int16_t AKWF_0823_256_DATA [256] = 
{424, 1589, 2764, 3985, 5251, 6565, 7930, 9337, 10787, 12274, 13783, 15310, 16840, 18352, 19841, 21283, 22662, 23970, 25192, 26323, 27361, 28298, 29135, 29876, 30522, 31074, 31543, 31928, 32233, 32465, 32628, 32728, 32767, 32752, 32687, 32576, 32424, 32232, 32006, 31750, 31466, 31155, 30825, 30474, 30106, 29724, 29328, 28921, 28500, 28062, 27609, 27134, 26636, 26109, 25552, 24957, 24325, 23653, 22936, 22176, 21369, 20515, 19616, 18675, 17691, 16674, 15626, 14552, 13462, 12356, 11236, 10115, 8985, 7855, 6732, 5611, 4495, 3394, 2303, 1229, 177, -859, -1870, -2855, -3814, -4745, -5644, -6515, -7352, -8158, -8933, -9671, -10375, -11039, -11654, -12211, -12702, -13114, -13436, -13662, -13789, -13814, -13738, -13567, -13306, -12963, -12545, -12062, -11521, -10935, -10307, -9650, -8974, -8281, -7582, -6884, -6190, -5508, -4843, -4200, -3583, -2999, -2447, -1933, -1459, -1025, -631, -270, 61, 369, 670, 960, 1248, 1541, 1842, 2145, 2455, 2769, 3081, 3386, 3672, 3933, 4158, 4332, 4450, 4502, 4485, 4394, 4233, 4003, 3711, 3360, 2957, 2509, 2022, 1505, 963, 403, -169, -748, -1330, -1909, -2484, -3050, -3602, -4142, -4665, -5168, -5652, -6115, -6553, -6970, -7363, -7729, -8073, -8393, -8688, -8963, -9221, -9466, -9703, -9936, -10169, -10407, -10652, -10910, -11183, -11471, -11778, -12105, -12453, -12820, -13204, -13601, -14009, -14423, -14842, -15259, -15676, -16090, -16496, -16899, -17297, -17687, -18073, -18450, -18822, -19185, -19538, -19883, -20219, -20544, -20861, -21167, -21465, -21753, -22032, -22301, -22564, -22816, -23056, -23282, -23484, -23653, -23778, -23845, -23845, -23771, -23615, -23374, -23047, -22641, -22155, -21596, -20970, -20282, -19539, -18749, -17916, -17043, -16141, -15209, -14252, -13277, -12280, -11270, -10249, -9213, -8170, -7121, -6062, -5000, -3933, -2859, -1779, -662};