/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0871 256 samples */
 
const int16_t AKWF_0871_256_DATA [256] = 
{705, 2536, 4292, 6014, 7697, 9343, 10955, 12523, 14061, 15563, 17025, 18456, 19853, 21213, 22543, 23843, 25106, 26340, 27530, 28772, 29510, 29120, 28740, 28372, 28009, 27643, 27332, 26816, 24818, 22600, 20496, 18433, 16415, 14449, 12532, 10662, 8840, 7067, 5334, 3651, 2010, 413, -1143, -2659, -4134, -5564, -6960, -8318, -9636, -10918, -12191, -13292, -13819, -14280, -14738, -15176, -15605, -16018, -16419, -16809, -17186, -17554, -17912, -18260, -18600, -18931, -19256, -19573, -19886, -20193, -20496, -20795, -21088, -21365, -21706, -21711, -19675, -17192, -14863, -12577, -10359, -8195, -6093, -4055, -2070, -145, 1715, 3528, 5282, 6979, 8626, 10217, 11754, 13241, 14680, 16066, 17405, 18692, 19952, 21090, 20969, 20492, 20078, 19645, 19207, 18761, 18315, 17863, 17407, 16950, 16489, 16025, 15562, 15096, 14607, 14234, 13224, 10756, 8343, 5976, 3652, 1380, -853, -3038, -5176, -7278, -9332, -11342, -13315, -15241, -17130, -18979, -20785, -22556, -24291, -25983, -27645, -29265, -30829, -32494, -31587, -28634, -25955, -23307, -20727, -18208, -15755, -13371, -11045, -8782, -6583, -4438, -2353, -330, 1641, 3557, 5416, 7225, 8980, 10682, 12343, 13941, 15526, 16951, 16528, 15595, 14787, 13921, 13725, 13999, 14195, 14393, 14580, 14761, 14933, 15097, 15252, 15404, 15550, 15693, 15829, 15962, 16095, 16224, 16347, 16474, 16598, 16725, 16851, 16976, 17101, 17250, 16671, 15739, 14883, 14129, 12717, 10544, 8506, 6518, 4584, 2705, 887, -878, -2589, -4242, -5845, -7394, -8886, -10334, -11731, -13075, -14374, -15624, -16825, -17983, -19096, -20162, -21175, -22221, -22418, -21912, -21489, -21042, -20587, -20128, -19664, -19192, -18718, -18238, -17754, -17268, -16780, -16287, -15795, -15301, -14805, -14309, -13812, -13315, -12822, -12327, -11834, -11343, -10854, -10367, -9885, -9405, -8928, -8456, -7974, -7565, -6824, -4922, -2994, -1089};