/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0872 256 samples */
 
const int16_t AKWF_0872_256_DATA [256] = 
{227, 1018, 1880, 2825, 3846, 4941, 6108, 7335, 8622, 9962, 11343, 12764, 14215, 15681, 17160, 18637, 20094, 21526, 22913, 24233, 25468, 26575, 27544, 28410, 29187, 29883, 30504, 31051, 31526, 31929, 32257, 32506, 32676, 32759, 32754, 32657, 32461, 32166, 31766, 31263, 30650, 29928, 29101, 28166, 27125, 25985, 24746, 23415, 22002, 20506, 18940, 17316, 15636, 13915, 12164, 10388, 8603, 6822, 5046, 3297, 1583, -90, -1706, -3258, -4740, -6137, -7446, -8660, -9769, -10773, -11664, -12439, -13096, -13635, -14052, -14349, -14529, -14591, -14541, -14379, -14115, -13750, -13291, -12747, -12121, -11426, -10666, -9847, -8983, -8080, -7142, -6182, -5208, -4222, -3239, -2263, -1298, -355, 561, 1448, 2295, 3100, 3857, 4558, 5199, 5777, 6281, 6710, 7056, 7315, 7482, 7550, 7517, 7379, 7132, 6777, 6308, 5729, 5041, 4244, 3342, 2341, 1243, 57, -1208, -2551, -3956, -5416, -6922, -8461, -10023, -11599, -13172, -14734, -16276, -17776, -19232, -20631, -21954, -23199, -24349, -25389, -26315, -27109, -27746, -28217, -28540, -28733, -28807, -28770, -28630, -28394, -28068, -27660, -27172, -26612, -25988, -25299, -24554, -23759, -22914, -22028, -21103, -20144, -19159, -18150, -17117, -16073, -15016, -13952, -12888, -11822, -10763, -9716, -8682, -7665, -6669, -5698, -4755, -3844, -2966, -2124, -1325, -564, 152, 821, 1448, 2025, 2554, 3036, 3468, 3851, 4187, 4474, 4716, 4913, 5066, 5177, 5250, 5286, 5286, 5255, 5196, 5111, 5002, 4874, 4730, 4572, 4405, 4233, 4037, 3778, 3444, 3031, 2533, 1946, 1278, 541, -245, -1052, -1848, -2604, -3287, -3874, -4349, -4699, -4925, -5033, -5033, -4943, -4781, -4569, -4327, -4075, -3831, -3606, -3414, -3261, -3148, -3078, -3046, -3046, -3067, -3100, -3133, -3154, -3150, -3110, -3023, -2880, -2671, -2390, -2033, -1593, -1072, -449};