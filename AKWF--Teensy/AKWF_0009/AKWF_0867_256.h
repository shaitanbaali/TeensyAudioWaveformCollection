/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0867 256 samples */
 
const int16_t AKWF_0867_256_DATA [256] = 
{32366, 30881, 29447, 27405, 29503, 8442, -6712, -8362, -15074, -14243, -14812, -15196, -15586, -15980, -16381, -16787, -17193, -17600, -18000, -18381, -18726, -19002, -19159, -19112, -18717, -17294, -17954, -2313, 27582, 23376, 22495, 21139, 19811, 18520, 17261, 16034, 14845, 13690, 12570, 11490, 10445, 9436, 8467, 7535, 6640, 5787, 4969, 4190, 3450, 2746, 2080, 1454, 862, 308, -209, -692, -1138, -1550, -1930, -2275, -2588, -2871, -3120, -3340, -3532, -3696, -3832, -3942, -4027, -4086, -4123, -4138, -4132, -4106, -4060, -3997, -3917, -3821, -3712, -3588, -3453, -3306, -3149, -2982, -2807, -2626, -2439, -2246, -2049, -1848, -1645, -1442, -1238, -1035, -832, -631, -433, -239, -49, 136, 316, 490, 659, 821, 974, 1119, 1257, 1386, 1506, 1618, 1720, 1812, 1895, 1968, 2032, 2084, 2129, 2162, 2186, 2202, 2207, 2203, 2190, 2167, 2136, 2096, 2050, 1994, 1932, 1861, 1785, 1702, 1614, 1520, 1421, 1317, 1209, 1097, 984, 866, 746, 624, 502, 379, 256, 133, 10, -112, -232, -350, -466, -579, -688, -795, -895, -993, -1086, -1174, -1257, -1335, -1405, -1471, -1531, -1583, -1628, -1668, -1700, -1726, -1744, -1755, -1759, -1755, -1746, -1729, -1705, -1673, -1636, -1592, -1541, -1483, -1420, -1352, -1278, -1198, -1114, -1024, -930, -834, -733, -628, -520, -411, -298, -185, -71, 45, 159, 276, 391, 505, 617, 728, 836, 942, 1044, 1142, 1236, 1326, 1409, 1488, 1561, 1627, 1686, 1739, 1784, 1819, 1847, 1867, 1877, 1877, 1870, 1851, 1822, 1782, 1732, 1670, 1598, 1513, 1418, 1311, 1191, 1060, 916, 759, 590, 410, 215, 9, -209, -442, -685, -943, -1214, -1496, -1793, -2102, -2424, -2759, -3106, -3465, -3839, -4225, -4623, -5035, -5459, -5904};