/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0890 256 samples */
 
const int16_t AKWF_0890_256_DATA [256] = 
{2292, 5785, 8803, 11492, 13879, 16001, 17887, 19556, 21040, 22359, 23527, 24565, 25487, 26304, 27030, 27676, 28246, 28755, 29206, 29605, 29961, 30276, 30556, 30804, 31025, 31220, 31395, 31548, 31685, 31807, 31915, 32010, 32095, 32171, 32238, 32297, 32350, 32397, 32438, 32476, 32508, 32537, 32563, 32586, 32606, 32624, 32640, 32654, 32667, 32678, 32688, 32697, 32705, 32712, 32718, 32723, 32728, 32733, 32737, 32740, 32743, 32746, 32748, 32751, 32751, 32754, 32706, 32733, 33078, 8727, 13935, 17087, 11017, 6245, 1885, -2007, -5467, -8528, -11253, -13672, -15813, -17720, -19411, -20908, -22242, -23425, -24473, -25406, -26233, -26966, -27618, -28196, -28710, -29166, -29570, -29929, -30248, -30532, -30782, -31005, -31203, -31379, -31535, -31673, -31796, -31905, -32002, -32087, -32164, -32232, -32292, -32345, -32392, -32434, -32473, -32505, -32535, -32561, -32583, -32604, -32622, -32638, -32653, -32666, -32677, -32688, -32696, -32704, -32711, -32718, -32723, -32728, -32732, -32736, -32740, -32743, -32745, -32747, -32750, -32751, -32754, -32755, -32756, -32757, -32758, -32760, -32760, -32761, -32761, -32763, -32764, -32763, -32764, -32765, -32764, -32764, -32765, -32766, -32765, -32765, -32765, -32765, -32766, -32765, -32766, -32767, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32686, -32965, -32197, -6655, -15589, -16455, -10577, -5837, -1455};