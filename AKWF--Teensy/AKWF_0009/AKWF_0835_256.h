/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0835 256 samples */
 
const int16_t AKWF_0835_256_DATA [256] = 
{1324, 3275, 5126, 6927, 8670, 10358, 11993, 13570, 15095, 16569, 17986, 19355, 20675, 21941, 23163, 24337, 25462, 26545, 27582, 28573, 29523, 30438, 31323, 32200, 32737, 32752, 32632, 32435, 32180, 31881, 31551, 31195, 30817, 30426, 30022, 29608, 29188, 28763, 28334, 27905, 27474, 27045, 26618, 26194, 25773, 25357, 24945, 24538, 24137, 23742, 23353, 22972, 22597, 22229, 21869, 21515, 21169, 20832, 20501, 20178, 19865, 19558, 19260, 18969, 18686, 18412, 18146, 17887, 17636, 17394, 17159, 16933, 16714, 16502, 16300, 16103, 15916, 15729, 15360, 14850, 14325, 13790, 13253, 12720, 12191, 11669, 11158, 10655, 10164, 9684, 9215, 8759, 8315, 7883, 7464, 7057, 6661, 6280, 5910, 5551, 5206, 4872, 4549, 4238, 3939, 3651, 3374, 3108, 2851, 2610, 2358, 1961, 1488, 1010, 530, 54, -417, -881, -1335, -1782, -2216, -2640, -3055, -3458, -3850, -4232, -4603, -4964, -5315, -5654, -5985, -6306, -6617, -6919, -7212, -7495, -7771, -8038, -8296, -8546, -8790, -9025, -9254, -9475, -9688, -9896, -10097, -10292, -10481, -10664, -10840, -11011, -11178, -11339, -11494, -11645, -11791, -11932, -12069, -12201, -12329, -12453, -12573, -12690, -12802, -12911, -13016, -13118, -13216, -13311, -13403, -13492, -13578, -13662, -13743, -13820, -13896, -13968, -14037, -14105, -14170, -14233, -14293, -14351, -14408, -14461, -14513, -14564, -14611, -14657, -14702, -14745, -14785, -14824, -14861, -14897, -14931, -14963, -14993, -15023, -15050, -15075, -15103, -15109, -15027, -14911, -14787, -14658, -14530, -14404, -14262, -14387, -14928, -15559, -16229, -16926, -17636, -18351, -19067, -19779, -20484, -21181, -21866, -22537, -23196, -23839, -24466, -25076, -25668, -26243, -26799, -27335, -27854, -28353, -28831, -29291, -29734, -30180, -30615, -31021, -31466, -31340, -29961, -27881, -25533, -23137, -20730, -18326, -15952, -13618, -11320, -9073, -6881, -4740, -2660, -596};