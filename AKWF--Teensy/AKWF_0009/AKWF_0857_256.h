/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0857 256 samples */
 
const int16_t AKWF_0857_256_DATA [256] = 
{148, 619, 1059, 1479, 1880, 2261, 2623, 2964, 3287, 3591, 3876, 4143, 4392, 4622, 4837, 5034, 5214, 5378, 5525, 5657, 5774, 5876, 5963, 6036, 6094, 6140, 6172, 6192, 6199, 6194, 6177, 6150, 6111, 6062, 6003, 5934, 5855, 5768, 5672, 5568, 5456, 5336, 5210, 5076, 4937, 4792, 4640, 4484, 4322, 4156, 3986, 3812, 3634, 3453, 3270, 3083, 2895, 2704, 2513, 2320, 2126, 1931, 1736, 1540, 1345, 1150, 956, 762, 570, 380, 190, 4, -180, -363, -543, -720, -895, -1066, -1234, -1399, -1559, -1716, -1869, -2017, -2162, -2303, -2438, -2569, -2695, -2816, -2932, -3044, -3149, -3250, -3346, -3436, -3521, -3600, -3673, -3742, -3804, -3860, -3911, -3956, -3995, -4029, -4057, -4079, -4096, -4107, -4112, -4111, -4104, -4093, -4075, -4051, -4022, -3989, -3949, -3903, -3853, -3797, -3736, -3671, -3599, -3523, -3442, -3355, -3265, -3170, -3069, -2964, -2856, -2743, -2624, -2503, -2377, -2248, -2114, -1977, -1836, -1692, -1543, -1391, -1237, -1079, -918, -754, -588, -418, -247, -72, 105, 283, 465, 648, 834, 1023, 1211, 1403, 1596, 1790, 1986, 2183, 2382, 2581, 2782, 2983, 3186, 3390, 3594, 3800, 4005, 4211, 4418, 4624, 4832, 5040, 5247, 5455, 5664, 5871, 6079, 6287, 6495, 6702, 6909, 7116, 7323, 7530, 7736, 7942, 8147, 8351, 8554, 8759, 8962, 9164, 9366, 9567, 9767, 9967, 10166, 10365, 10563, 10760, 10957, 11152, 11347, 11542, 11736, 11929, 12121, 12314, 12505, 12696, 12533, 14682, 6685, -32566, -31005, -29695, -28545, -27348, -26168, -25011, -23872, -22752, -21657, -20581, -19524, -18493, -17480, -16488, -15522, -14576, -13650, -12750, -11870, -11012, -10179, -9365, -8575, -7809, -7063, -6340, -5641, -4962, -4306, -3673, -3061, -2471, -1903, -1357, -833, -321};