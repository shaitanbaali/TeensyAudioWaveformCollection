/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0828 256 samples */
 
const int16_t AKWF_0828_256_DATA [256] = 
{29, 124, 216, 308, 400, 491, 583, 674, 765, 856, 947, 1038, 1128, 1218, 1309, 1399, 1489, 1580, 1669, 1759, 1849, 1939, 2028, 2118, 2207, 2297, 2386, 2475, 2565, 2654, 2744, 2833, 2922, 3011, 3100, 3189, 3278, 3368, 3457, 3546, 3635, 3724, 3813, 3902, 3992, 4080, 4169, 4259, 4348, 4436, 4526, 4615, 4704, 4793, 4882, 4971, 5061, 5149, 5239, 5328, 5417, 5507, 5596, 5685, 5775, 5864, 5953, 6043, 6132, 6221, 6311, 6400, 6490, 6580, 6669, 6759, 6848, 6938, 7027, 7117, 7207, 7297, 7386, 7476, 7566, 7655, 7745, 7835, 7925, 8015, 8104, 8194, 8284, 8374, 8464, 8553, 8643, 8734, 8824, 8913, 9004, 9093, 9183, 9274, 9364, 9453, 9543, 9633, 9724, 9814, 9904, 9994, 10084, 10174, 10265, 10355, 10444, 10535, 10625, 10715, 10806, 10896, 10987, 11077, 11167, 11258, 11347, 11437, 11527, 11618, 11708, 11799, 11889, 11979, 12070, 12160, 12250, 12341, 12431, 12521, 12612, 12698, 12293, 15111, -6886, -33337, -31814, -30274, -28350, -26560, -24979, -23587, -22364, -21284, -20321, -19460, -18688, -17986, -17349, -16766, -16229, -15731, -15267, -14833, -14426, -14040, -13675, -13328, -12996, -12678, -12374, -12080, -11796, -11523, -11257, -11000, -10751, -10507, -10271, -10041, -9816, -9598, -9384, -9175, -8970, -8771, -8575, -8383, -8196, -8012, -7831, -7655, -7481, -7311, -7144, -6979, -6819, -6660, -6504, -6352, -6201, -6053, -5907, -5763, -5622, -5483, -5345, -5209, -5077, -4945, -4815, -4687, -4561, -4436, -4313, -4190, -4070, -3951, -3832, -3716, -3601, -3487, -3374, -3263, -3151, -3041, -2932, -2824, -2718, -2612, -2506, -2402, -2298, -2195, -2092, -1990, -1889, -1789, -1689, -1590, -1491, -1392, -1295, -1198, -1100, -1004, -908, -813, -718, -624, -528, -434, -340, -247, -154, -59};