/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0820 256 samples */
 
const int16_t AKWF_0820_256_DATA [256] = 
{3214, 21867, 27962, 15369, -9703, -30549, -30851, -18073, -3146, 6483, 10199, 10486, 9043, 6906, 4689, 2723, 1152, -2, -773, -1233, -1466, -1555, -1576, -1594, -1654, -1786, -2001, -2291, -2632, -2993, -3327, -3591, -3738, -3738, -3516, -2788, -1525, -25, 1268, 1977, 1925, 1143, -141, -1545, -2591, -2801, -1813, 517, 4058, 8400, 12949, 16342, 16874, 14922, 12409, 11138, 10767, 8649, 1557, -10668, -22214, -28462, -28549, -24411, -18414, -12077, -6235, -1313, 2503, 5230, 6960, 7827, 7994, 7629, 6883, 5898, 4796, 3683, 2638, 1718, 969, 410, 49, -119, -117, 30, 289, 629, 1006, 1386, 1735, 2021, 2221, 2314, 2289, 2143, 1847, 1159, 16, -1363, -2639, -3548, -3974, -3909, -3409, -2572, -1532, -424, 607, 1424, 1918, 2007, 1649, 851, -336, -1811, -3445, -5072, -6516, -7638, -8119, -8076, -7319, -4491, -1862, 8688, 9307, -348, -926, 2907, 9596, 12441, 12037, 10060, 7445, 4770, 2363, 387, -1096, -2116, -2726, -3000, -3024, -2880, -2644, -2380, -2141, -1965, -1873, -1878, -1972, -2143, -2364, -2607, -2836, -3017, -3119, -3114, -2982, -2702, -2030, -840, 669, 2167, 3359, 4115, 4412, 4292, 3829, 3109, 2228, 1271, 319, -552, -1285, -1830, -2151, -2229, -2056, -1643, -1013, -201, 737, 1752, 2774, 3738, 4583, 5244, 5668, 5820, 5646, 4739, 2921, 531, -1907, -3950, -5389, -6199, -6437, -6205, -5621, -4799, -3845, -2843, -1860, -951, -147, 530, 1071, 1474, 1748, 1903, 1953, 1916, 1807, 1645, 1445, 1221, 982, 743, 511, 288, 83, -102, -268, -413, -536, -640, -723, -790, -839, -878, -916, -950, -970, -967, -936, -882, -802, -704, -594, -476, -353, -229, -104, 16, 127, 257, 436, 51, -1827, -4813, -4781, 6166, 7193, -2012};