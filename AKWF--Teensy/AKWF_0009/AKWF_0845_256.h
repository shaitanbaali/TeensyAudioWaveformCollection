/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0845 256 samples */
 
const int16_t AKWF_0845_256_DATA [256] = 
{366, 979, 1573, 2164, 2749, 3329, 3905, 4473, 5034, 5590, 6138, 6680, 7215, 7741, 8260, 8773, 9275, 9770, 10257, 10735, 11205, 11665, 12115, 12557, 12989, 13411, 13824, 14226, 14618, 15000, 15371, 15732, 16082, 16421, 16749, 17066, 17371, 17665, 17948, 18219, 18479, 18727, 18962, 19185, 19397, 19596, 19783, 19957, 20120, 20270, 20407, 20531, 20644, 20743, 20830, 20904, 20966, 21014, 21050, 21072, 21086, 21027, 20875, 20682, 20456, 20203, 19927, 19630, 19315, 18982, 18633, 18270, 17893, 17502, 17101, 16686, 16261, 15827, 15381, 14927, 14464, 13992, 13512, 13026, 12531, 12029, 11523, 11008, 10488, 9964, 9433, 8896, 8357, 7811, 7264, 6711, 6155, 5597, 5035, 4470, 3902, 3334, 2761, 2189, 1615, 1038, 462, -116, -695, -1272, -1851, -2429, -3006, -3585, -4163, -4737, -5312, -5886, -6457, -7028, -7595, -8160, -8724, -9284, -9841, -10397, -10948, -11496, -12041, -12582, -13119, -13652, -14180, -14704, -15224, -15737, -16248, -16753, -17251, -17744, -18233, -18715, -19191, -19662, -20125, -20583, -21034, -21477, -21915, -22346, -22769, -23184, -23593, -23994, -24388, -24774, -25151, -25522, -25884, -26237, -26582, -26919, -27247, -27567, -27877, -28179, -28473, -28756, -29031, -29297, -29553, -29800, -30038, -30266, -30485, -30694, -30892, -31082, -31262, -31431, -31591, -31741, -31880, -32010, -32130, -32238, -32337, -32427, -32505, -32573, -32632, -32680, -32717, -32744, -32761, -32767, -32676, -32489, -32257, -31989, -31690, -31364, -31015, -30645, -30255, -29847, -29422, -28982, -28527, -28058, -27576, -27083, -26576, -26060, -25534, -24996, -24451, -23897, -23333, -22763, -22186, -21600, -21009, -20412, -19809, -19201, -18589, -17971, -17350, -16725, -16095, -15465, -14830, -14193, -13556, -12915, -12273, -11632, -10988, -10343, -9701, -9057, -8412, -7772, -7130, -6489, -5853, -5216, -4581, -3951, -3321, -2696, -2075, -1456, -844, -223};