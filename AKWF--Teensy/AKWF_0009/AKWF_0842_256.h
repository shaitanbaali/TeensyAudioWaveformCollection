/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0842 256 samples */
 
const int16_t AKWF_0842_256_DATA [256] = 
{782, 2277, 3912, 5696, 7600, 9601, 11670, 13766, 15862, 17921, 19898, 21766, 23489, 25028, 26361, 27460, 28299, 28870, 29152, 29191, 29181, 29159, 29112, 29031, 28907, 28735, 28506, 28214, 27854, 27420, 26910, 26318, 25643, 24883, 24039, 23106, 22092, 20994, 19813, 18559, 17231, 15835, 14380, 12866, 11305, 9707, 8074, 6417, 4750, 3074, 1404, -248, -1881, -3476, -5025, -6526, -7960, -9321, -10604, -11795, -12888, -13880, -14760, -15523, -16165, -16681, -17068, -17324, -17443, -17456, -17451, -17440, -17416, -17375, -17314, -17228, -17115, -16971, -16794, -16580, -16330, -16039, -15708, -15336, -14920, -14463, -13965, -13425, -12845, -12230, -11575, -10888, -10170, -9423, -8651, -7860, -7049, -6227, -5396, -4558, -3724, -2893, -2072, -1267, -479, 284, 1017, 1718, 2383, 3004, 3582, 4110, 4584, 5004, 5367, 5668, 5907, 6084, 6193, 6238, 6224, 6098, 5739, 5055, 3972, 2440, 451, -1986, -4833, -8009, -11425, -14972, -18506, -21907, -25040, -27766, -29983, -31598, -32532, -32776, -32759, -32747, -32705, -32628, -32509, -32339, -32108, -31812, -31441, -30992, -30461, -29840, -29128, -28325, -27425, -26429, -25342, -24158, -22885, -21525, -20077, -18555, -16960, -15295, -13574, -11801, -9983, -8137, -6264, -4375, -2488, -604, 1263, 3096, 4894, 6643, 8327, 9944, 11481, 12924, 14270, 15510, 16630, 17631, 18503, 19239, 19837, 20292, 20601, 20760, 20788, 20783, 20775, 20758, 20727, 20680, 20614, 20524, 20410, 20268, 20097, 19894, 19657, 19385, 19077, 18734, 18352, 17933, 17476, 16982, 16452, 15887, 15285, 14652, 13990, 13296, 12576, 11834, 11069, 10286, 9490, 8680, 7864, 7043, 6219, 5402, 4590, 3788, 3003, 2235, 1489, 769, 80, -577, -1196, -1776, -2314, -2805, -3250, -3644, -3983, -4270, -4501, -4675, -4792, -4848, -4854, -4830, -4751, -4585, -4303, -3882, -3304, -2554, -1627, -484};