/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0894 256 samples */
 
const int16_t AKWF_0894_256_DATA [256] = 
{5485, 1578, 2898, 3980, 4958, 5792, 6496, 7088, 7590, 8020, 8393, 8722, 9019, 9295, 9558, 9813, 10066, 10321, 10719, 10197, 15636, 15421, 14117, 15623, 16699, 17671, 18528, 19282, 19953, 20556, 21102, 21231, 23950, 13435, 7679, 16632, 13076, 10971, 9077, 7504, 6191, 5078, 4113, 3244, 2431, 1644, 855, 44, -798, -1684, -2611, -3577, -4437, -6284, -2965, -3006, -6400, -6085, -6219, -6379, -6580, -6793, -6989, -7145, -7239, -7259, -7192, -7035, -6787, -6449, -6027, -5532, -4971, -4360, -3713, -3043, -2366, -1699, -1054, -380, -254, 2161, 6810, 3697, 5067, 6147, 7060, 7789, 8350, 8769, 9071, 9281, 9419, 9508, 9564, 9603, 9639, 9685, 9748, 9834, 9590, 11711, -4637, -554, 2895, -374, -2529, -4364, -5874, -7117, -8167, -9077, -9897, -10672, -11433, -12207, -13014, -13866, -14768, -15725, -16656, -18203, -17052, -14294, -18821, -18758, -18965, -19210, -19507, -19828, -20141, -20416, -20634, -20772, -20822, -20773, -20621, -20368, -20017, -19575, -19055, -18368, -18293, -11994, -12961, -13085, -11253, -9782, -8451, -7279, -6256, -5364, -4599, -3946, -3395, -2937, -2561, -2256, -2014, -1826, -1681, -1831, -49, -7671, -18044, -7984, -11590, -14081, -16341, -18264, -19890, -21286, -22506, -23591, -24587, -25528, -26436, -27335, -28174, -29548, -28471, -25335, -29775, -29656, -29783, -29987, -30284, -30645, -31040, -31442, -31820, -32155, -32429, -32628, -32740, -32762, -32690, -32525, -32273, -31846, -32051, -28806, -25091, -27813, -26004, -24599, -23276, -22081, -21019, -20069, -19226, -18483, -17828, -17255, -16759, -16329, -15961, -15650, -15388, -15169, -14991, -14845, -14727, -14634, -14561, -14503, -14458, -14422, -14391, -14349, -14460, -13871, -8437, -11665, -11140, -10154, -9324, -8602, -7977, -7428, -6940, -6495, -6079, -5684, -5300, -4921, -4544, -4165, -3783, -3403, -3021, -2642, -2271, -1908, -1562, -1225};