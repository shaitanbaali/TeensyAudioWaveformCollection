/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0887 256 samples */
 
const int16_t AKWF_0887_256_DATA [256] = 
{580, 506, 1807, 3549, 5430, 7351, 9255, 11106, 12890, 14595, 16207, 17729, 19158, 20488, 21724, 22869, 23920, 24884, 25765, 26561, 27279, 27920, 28487, 28986, 29419, 29787, 30095, 30345, 30540, 30683, 30776, 30821, 30821, 30779, 30695, 30572, 30413, 30219, 29990, 29731, 29442, 29124, 28780, 28408, 28012, 27595, 27154, 26692, 26212, 25713, 25194, 24661, 24112, 23547, 22970, 22377, 21773, 21158, 20532, 19894, 19250, 18594, 17931, 17261, 16583, 15899, 15210, 14515, 13815, 13110, 12402, 11692, 10977, 10259, 9542, 8822, 8099, 7379, 6654, 5932, 5212, 4489, 3768, 3051, 2331, 1616, 904, 193, -514, -1218, -1918, -2617, -3309, -3999, -4683, -5362, -6040, -6708, -7372, -8032, -8684, -9331, -9972, -10606, -11233, -11856, -12469, -13076, -13677, -14268, -14854, -15433, -16000, -16562, -17117, -17660, -18198, -18726, -19244, -19756, -20259, -20751, -21235, -21710, -22175, -22633, -23080, -23516, -23946, -24363, -24772, -25171, -25560, -25940, -26309, -26668, -27017, -27357, -27685, -28005, -28313, -28611, -28900, -29178, -29445, -29703, -29949, -30186, -30412, -30627, -30833, -31028, -31213, -31387, -31550, -31704, -31847, -31979, -32101, -32213, -32315, -32405, -32486, -32558, -32617, -32667, -32707, -32737, -32757, -32766, -32766, -32755, -32735, -32705, -32665, -32615, -32556, -32486, -32408, -32319, -32221, -32113, -31997, -31871, -31735, -31591, -31438, -31275, -31104, -30923, -30734, -30536, -30329, -30114, -29891, -29659, -29418, -29170, -28913, -28650, -28375, -28096, -27808, -27512, -27209, -26899, -26580, -26254, -25923, -25583, -25237, -24883, -24524, -24157, -23785, -23404, -23020, -22627, -22230, -21826, -21417, -21001, -20581, -20155, -19723, -19287, -18845, -18397, -17947, -17491, -17029, -16564, -16095, -15620, -15143, -14661, -14175, -13687, -13193, -12697, -12197, -11695, -11188, -10681, -10169, -9654, -9139, -8618, -8097, -7575, -7050, -6521, -5993, -5462, -4940, -4357};