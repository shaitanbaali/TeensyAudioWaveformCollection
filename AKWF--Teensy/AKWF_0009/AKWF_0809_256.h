/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0809 256 samples */
 
const int16_t AKWF_0809_256_DATA [256] = 
{1309, 3460, 5488, 7433, 9192, 10655, 11781, 12642, 13348, 13952, 14437, 14722, 14765, 14569, 14168, 13667, 13205, 12847, 12621, 12485, 12330, 12103, 11795, 11507, 11329, 11291, 11394, 11628, 11966, 12383, 12844, 13319, 13786, 14215, 14591, 14900, 15127, 15263, 15304, 15246, 15086, 14827, 14470, 14015, 13474, 12844, 12130, 11341, 10485, 9564, 8591, 7572, 6505, 5408, 4287, 3142, 1986, 826, -338, -1497, -2640, -3768, -4870, -5942, -6957, -7821, -8483, -8941, -9211, -9336, -9354, -9308, -9232, -9157, -9105, -9093, -9131, -9221, -9367, -9567, -9808, -10082, -10381, -10691, -11001, -11300, -11576, -11817, -12015, -12153, -12227, -12240, -12179, -12043, -11833, -11542, -11175, -10731, -10217, -9633, -8986, -8282, -7526, -6727, -5890, -5019, -4125, -3215, -2298, -1377, -459, 448, 1339, 2215, 3062, 3874, 4657, 5400, 6104, 6767, 7385, 7956, 8481, 8964, 9402, 9795, 10142, 10450, 10722, 10954, 11149, 11312, 11450, 11563, 11648, 11717, 11770, 11805, 11827, 11833, 11830, 11821, 11807, 11794, 11780, 11764, 11756, 11751, 11744, 11740, 11743, 11749, 11758, 11772, 11784, 11797, 11812, 11824, 11827, 11824, 11820, 11811, 11789, 11755, 11711, 11650, 11571, 11473, 11359, 11222, 11064, 10885, 10678, 10449, 10195, 9915, 9611, 9275, 8910, 8524, 8106, 7664, 7198, 6704, 6186, 5647, 5083, 4499, 3899, 3278, 2642, 1994, 1333, 657, -28, -720, -1415, -2116, -2816, -3515, -4214, -4906, -5590, -6267, -6931, -7587, -8232, -8859, -9469, -10061, -10637, -11190, -11718, -12226, -12709, -13172, -13610, -14022, -14411, -14770, -15099, -15406, -15684, -15935, -16163, -16363, -16660, -17274, -18369, -20020, -22100, -24386, -26614, -28561, -30119, -31260, -32025, -32504, -32748, -32708, -32298, -31489, -30333, -28963, -27472, -25883, -24135, -22161, -19889, -17284, -14406, -11440, -8531, -5763, -3206, -830};