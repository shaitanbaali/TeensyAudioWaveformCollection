/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0846 256 samples */
 
const int16_t AKWF_0846_256_DATA [256] = 
{513, 1843, 3142, 4440, 5728, 7008, 8278, 9530, 10769, 11991, 13190, 14369, 15526, 16655, 17759, 18835, 19878, 20891, 21872, 22815, 23725, 24597, 25430, 26223, 26975, 27685, 28353, 28976, 29553, 30086, 30572, 31011, 31403, 31745, 32039, 32284, 32479, 32624, 32717, 32771, 32663, 32334, 31909, 31408, 30848, 30236, 29578, 28879, 28147, 27380, 26584, 25763, 24916, 24048, 23163, 22256, 21337, 20405, 19457, 18502, 17539, 16567, 15591, 14613, 13630, 12648, 11667, 10686, 9711, 8740, 7775, 6819, 5871, 4932, 4008, 3094, 2193, 1310, 440, -411, -1242, -2056, -2851, -3622, -4372, -5099, -5800, -6479, -7132, -7756, -8355, -8925, -9466, -9979, -10461, -10912, -11333, -11722, -12080, -12405, -12696, -12954, -13180, -13371, -13529, -13652, -13741, -13796, -13813, -13677, -13411, -13083, -12705, -12287, -11835, -11354, -10848, -10321, -9777, -9216, -8642, -8061, -7471, -6875, -6279, -5681, -5084, -4492, -3904, -3324, -2754, -2194, -1648, -1116, -599, -102, 376, 835, 1270, 1683, 2072, 2435, 2772, 3081, 3360, 3611, 3832, 4023, 4182, 4310, 4406, 4469, 4504, 4460, 4304, 4099, 3857, 3584, 3285, 2965, 2624, 2264, 1888, 1497, 1093, 675, 245, -194, -644, -1103, -1569, -2044, -2526, -3012, -3504, -4002, -4502, -5007, -5514, -6022, -6534, -7046, -7558, -8070, -8582, -9091, -9600, -10106, -10609, -11109, -11605, -12096, -12583, -13065, -13541, -14011, -14474, -14930, -15379, -15819, -16252, -16677, -17091, -17497, -17892, -18277, -18652, -19017, -19370, -19711, -20041, -20358, -20664, -20956, -21236, -21503, -21756, -21995, -22221, -22434, -22631, -22815, -22983, -23138, -23278, -23402, -23512, -23607, -23685, -23750, -23799, -23829, -23859, -23785, -23400, -22841, -22177, -21425, -20597, -19706, -18761, -17763, -16720, -15640, -14520, -13369, -12191, -10984, -9757, -8512, -7247, -5970, -4684, -3387, -2088, -760};