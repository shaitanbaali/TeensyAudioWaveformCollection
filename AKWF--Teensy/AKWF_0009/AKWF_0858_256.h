/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0858 256 samples */
 
const int16_t AKWF_0858_256_DATA [256] = 
{824, 2807, 4784, 6785, 8764, 10718, 12633, 14489, 16255, 17929, 19484, 20906, 22185, 23310, 24250, 25012, 25573, 25930, 26090, 26031, 25762, 25274, 24559, 23637, 22509, 21185, 19666, 17951, 16074, 14042, 11859, 9563, 7157, 4652, 2092, -522, -3157, -5805, -8424, -11005, -13529, -15963, -18306, -20513, -22587, -24490, -26212, -27736, -29053, -30141, -30999, -31622, -31981, -32088, -31943, -31525, -30852, -29922, -28750, -27324, -25673, -23798, -21706, -19429, -16978, -14390, -11654, -8835, -5937, -2990, -22, 2954, 5899, 8797, 11618, 14342, 16945, 19408, 21711, 23817, 25738, 27461, 28955, 30214, 31229, 31983, 32488, 32736, 32731, 32459, 31936, 31169, 30162, 28920, 27463, 25804, 23954, 21933, 19760, 17441, 15014, 12492, 9893, 7247, 4572, 1895, -776, -3411, -5988, -8468, -10865, -13141, -15274, -17275, -19089, -20734, -22188, -23443, -24480, -25317, -25930, -26322, -26500, -26458, -26203, -25739, -25065, -24219, -23171, -21961, -20609, -19099, -17469, -15731, -13895, -12002, -10038, -8037, -6018, -4001, -2003, -42, 1883, 3729, 5490, 7158, 8720, 10160, 11447, 12604, 13620, 14476, 15166, 15704, 16065, 16260, 16297, 16186, 15898, 15480, 14914, 14230, 13409, 12487, 11480, 10364, 9193, 7963, 6691, 5390, 4076, 2771, 1487, 231, -979, -2131, -3215, -4217, -5130, -5937, -6644, -7230, -7701, -8053, -8279, -8376, -8356, -8217, -7964, -7595, -7122, -6551, -5897, -5171, -4364, -3513, -2620, -1696, -741, 207, 1157, 2082, 2969, 3811, 4599, 5315, 5953, 6502, 6948, 7302, 7540, 7642, 7627, 7510, 7265, 6893, 6400, 5800, 5091, 4272, 3359, 2362, 1289, 160, -1029, -2262, -3510, -4779, -6044, -7295, -8516, -9671, -10789, -11818, -12774, -13625, -14372, -14996, -15472, -15833, -16029, -16077, -15970, -15708, -15266, -14680, -13934, -13027, -11971, -10761, -9424, -7970, -6387, -4698, -2924, -1036};