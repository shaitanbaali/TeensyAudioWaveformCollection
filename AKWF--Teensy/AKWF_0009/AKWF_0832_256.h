/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0832 256 samples */
 
const int16_t AKWF_0832_256_DATA [256] = 
{156, 550, 932, 1309, 1676, 2030, 2371, 2700, 3018, 3329, 3630, 3921, 4201, 4473, 4737, 4999, 5263, 5528, 5786, 6041, 6323, 6649, 7003, 7358, 7717, 8099, 8515, 8960, 9430, 9919, 10416, 10917, 11427, 11943, 12468, 13000, 13525, 14042, 14554, 15057, 15557, 16050, 16534, 17007, 17471, 17925, 18371, 18816, 19260, 19703, 20139, 20565, 20991, 21418, 21844, 22270, 22693, 23112, 23528, 23941, 24355, 24781, 25225, 25671, 26104, 26528, 26961, 27407, 27857, 28308, 28756, 29199, 29639, 30080, 30520, 30960, 31393, 31816, 32234, 32580, 32749, 32764, 32749, 32729, 32621, 32364, 31968, 31450, 30838, 30161, 29424, 28613, 27717, 26747, 25733, 24687, 23607, 22501, 21383, 20263, 19146, 18018, 16889, 15773, 14671, 13583, 12515, 11460, 10418, 9394, 8387, 7402, 6446, 5506, 4581, 3672, 2780, 1907, 1056, 220, -599, -1405, -2200, -2979, -3742, -4495, -5236, -5969, -6704, -7432, -8150, -8859, -9561, -10262, -10960, -11653, -12339, -13018, -13669, -14275, -14843, -15398, -15942, -16452, -16907, -17317, -17691, -18032, -18346, -18627, -18874, -19087, -19269, -19429, -19571, -19694, -19799, -19886, -19958, -20022, -20087, -20151, -20205, -20252, -20296, -20342, -20391, -20440, -20488, -20536, -20582, -20628, -20675, -20721, -20765, -20802, -20826, -20843, -20857, -20869, -20872, -20865, -20848, -20822, -20791, -20753, -20710, -20660, -20604, -20541, -20476, -20413, -20356, -20303, -20247, -20190, -20136, -20089, -20048, -20012, -19977, -19943, -19911, -19884, -19873, -19917, -19995, -20003, -19876, -19683, -19511, -19358, -19166, -18904, -18565, -18163, -17724, -17276, -16818, -16335, -15817, -15273, -14727, -14192, -13673, -13166, -12660, -12152, -11655, -11175, -10713, -10265, -9826, -9391, -8962, -8542, -8131, -7728, -7327, -6924, -6514, -6100, -5690, -5283, -4872, -4455, -4035, -3610, -3185, -2762, -2338, -1914, -1490, -1067, -648, -230};