/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0829 256 samples */
 
const int16_t AKWF_0829_256_DATA [256] = 
{182, 509, 830, 1151, 1471, 1793, 2113, 2433, 2753, 3073, 3393, 3713, 4032, 4351, 4670, 4989, 5307, 5627, 5946, 6263, 6582, 6900, 7218, 7537, 7854, 8171, 8488, 8806, 9123, 9441, 9758, 10075, 10393, 10709, 11025, 11343, 11660, 11976, 12294, 12609, 12926, 13243, 13559, 13876, 14192, 14508, 14824, 15141, 15458, 15774, 16091, 16406, 16722, 17039, 17355, 17672, 17988, 18303, 18621, 18937, 19253, 19569, 19885, 20201, 20518, 20834, 21150, 21467, 21784, 22100, 22416, 22732, 23049, 23365, 23681, 23998, 24315, 24631, 24948, 25264, 25581, 25898, 26214, 26531, 26847, 27165, 27481, 27798, 28115, 28432, 28750, 29065, 29382, 29700, 30018, 30333, 30650, 30968, 31285, 31603, 31920, 32234, 32558, 32768, 32580, 31956, 30975, 29701, 28197, 26522, 24708, 22799, 20829, 18814, 16782, 14753, 12732, 10738, 8783, 6865, 4998, 3188, 1430, -264, -1896, -3468, -4974, -6415, -7796, -9109, -10360, -11551, -12680, -13750, -14763, -15717, -16617, -17465, -18260, -19006, -19704, -20354, -20960, -21522, -22041, -22521, -22962, -23365, -23733, -24067, -24367, -24636, -24875, -25084, -25267, -25422, -25552, -25658, -25740, -25800, -25840, -25858, -25859, -25840, -25804, -25752, -25683, -25600, -25502, -25390, -25266, -25130, -24981, -24822, -24652, -24472, -24283, -24085, -23878, -23663, -23441, -23212, -22975, -22733, -22483, -22230, -21970, -21706, -21436, -21162, -20884, -20602, -20317, -20028, -19736, -19440, -19142, -18841, -18538, -18234, -17925, -17616, -17305, -16992, -16678, -16362, -16045, -15726, -15407, -15086, -14764, -14443, -14121, -13796, -13472, -13148, -12822, -12498, -12172, -11844, -11518, -11192, -10865, -10539, -10211, -9884, -9557, -9229, -8903, -8576, -8249, -7922, -7596, -7268, -6943, -6617, -6289, -5964, -5638, -5312, -4988, -4662, -4337, -4013, -3688, -3363, -3040, -2716, -2392, -2070, -1746, -1423, -1101, -778, -457, -130};