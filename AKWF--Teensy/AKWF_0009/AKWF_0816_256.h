/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0816 256 samples */
 
const int16_t AKWF_0816_256_DATA [256] = 
{2358, 6978, 9177, 9941, 9782, 9050, 7996, 6796, 5558, 4354, 3236, 2218, 1315, 531, -140, -702, -1163, -1535, -1826, -2044, -2199, -2299, -2352, -2366, -2344, -2294, -2221, -2128, -2024, -1885, -1841, -2037, -1694, -1453, 590, 1603, 37, -675, -1923, -2409, -1702, -1264, -896, -597, -351, -148, 19, 158, 273, 369, 446, 509, 559, 598, 625, 644, 656, 662, 618, 644, 959, -16979, -14051, -2845, 2348, 5588, 7207, 7757, 7621, 7062, 6267, 5362, 4429, 3520, 2672, 1898, 1208, 607, 88, -350, -713, -1010, -1246, -1428, -1563, -1657, -1714, -1740, -1741, -1718, -1686, -1594, -1677, -2773, -2249, -1503, -880, 3364, 5644, 1841, -384, -2352, -6186, -6206, -3659, -2192, -1125, -393, 99, 421, 626, 750, 816, 844, 847, 832, 807, 775, 739, 700, 662, 625, 535, 539, 890, -20438, -16971, -3665, 2501, 6351, 8279, 8940, 8782, 8127, 7195, 6134, 5043, 3983, 2993, 2090, 1286, 587, -14, -520, -939, -1279, -1546, -1751, -1900, -1999, -2056, -2079, -2070, -2035, -1978, -1904, -1821, -1707, -1685, -1898, -1576, -1353, 674, 1671, 85, -644, -1907, -2408, -1716, -1293, -933, -641, -402, -207, -45, 88, 197, 288, 363, 424, 471, 507, 536, 557, 571, 578, 536, 566, 884, -17035, -14107, -2908, 2285, 5526, 7148, 7700, 7564, 7010, 6220, 5322, 4394, 3491, 2648, 1879, 1193, 596, 81, -352, -713, -1007, -1241, -1421, -1554, -1648, -1711, -1673, -2752, -2919, -2002, -1534, -1204, -987, -820, -862, 424, 4625, 3484, 291, -1246, -4062, -9126, -8144, -3861, -1479, 109, 1078, 1620, 1874, 1941, 1889, 1767, 1606, 1427, 1246, 1071, 910, 763, 631, 515, 415, 267, 238, 621, -24032, -20025, -4625};