/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0881 256 samples */
 
const int16_t AKWF_0881_256_DATA [256] = 
{2451, 6494, 7887, 9237, 10352, 11338, 12233, 13055, 13821, 14540, 15215, 15857, 16467, 17046, 17600, 18129, 18633, 19116, 19578, 20020, 20442, 20846, 21230, 21598, 21947, 22279, 22593, 22891, 23172, 23437, 23684, 23916, 24131, 24330, 24514, 24682, 24833, 24970, 25090, 25195, 25286, 25362, 25423, 25470, 25502, 25521, 25528, 25519, 25500, 25467, 25422, 25366, 25299, 25220, 25132, 25033, 24926, 24808, 24683, 24550, 24409, 24260, 24105, 23943, 23776, 23603, 23426, 23243, 23057, 22867, 22673, 22478, 22279, 22079, 21877, 21675, 21471, 21267, 21063, 20860, 20658, 20457, 20257, 20060, 19864, 19672, 19484, 19298, 19116, 18940, 18767, 18600, 18438, 18282, 18132, 17989, 17852, 17722, 17600, 17485, 17379, 17280, 17190, 17109, 17037, 16973, 16919, 16874, 16834, 16797, 16759, 16715, 16665, 16607, 16540, 16466, 16386, 16301, 16211, 16117, 16020, 15919, 15813, 15700, 15582, 15456, 15322, 15179, 15026, 14863, 14687, 14496, 14294, 14075, 13839, 13586, 13312, 13017, 12700, 12356, 11984, 11582, 11144, 10666, 10143, 9562, 8910, 8171, 7301, 6171, 5141, 61, -5038, -6247, -7529, -8574, -9509, -10375, -11190, -11967, -12718, -13444, -14151, -14847, -15528, -16201, -16867, -17523, -18168, -18801, -19418, -20020, -20606, -21174, -21730, -22274, -22805, -23327, -23842, -24347, -24846, -25335, -25815, -26288, -26750, -27202, -27643, -28074, -28491, -28897, -29288, -29663, -30025, -30368, -30694, -31002, -31290, -31556, -31799, -32019, -32213, -32381, -32519, -32629, -32707, -32754, -32768, -32750, -32700, -32617, -32504, -32361, -32189, -31990, -31766, -31515, -31243, -30948, -30632, -30296, -29941, -29569, -29178, -28771, -28348, -27911, -27459, -26991, -26511, -26018, -25510, -24991, -24459, -23913, -23356, -22785, -22200, -21604, -20992, -20364, -19724, -19064, -18387, -17692, -16974, -16232, -15465, -14664, -13825, -12943, -12002, -10986, -9871, -8603, -7112, -4861};