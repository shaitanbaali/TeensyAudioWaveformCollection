/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0847 256 samples */
 
const int16_t AKWF_0847_256_DATA [256] = 
{32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32633, 33289, 30878, 1889, -522, 134, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -216, 961, -4935, -14820, -13590, -13816, -13816, -13816, -13816, -13816, -13816, -13816, -13816, -13816, -13816, -13816, -13816, -13816, -13816, -13816, -13624, -14687, -9602, 888, -197, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 20, -81, 297, 4281, 4568, 4488, 4505, 4505, 4505, 4505, 4505, 4505, 4505, 4505, 4494, 4535, 4416, 459, -118, 27, 0, 0, 0, 0, 0, 0, 0, 0, -24, -59, 412, -19971, -24780, -23651, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23853, -23547, -25256, -6674, 1415, -311, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0};