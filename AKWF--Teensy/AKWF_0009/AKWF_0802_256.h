/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0802 256 samples */
 
const int16_t AKWF_0802_256_DATA [256] = 
{811, 3440, 5391, 6857, 7904, 8603, 9007, 9169, 9132, 8931, 8601, 8168, 7654, 7084, 6470, 5829, 5176, 4518, 3865, 3227, 2607, 2012, 1447, 911, 411, -53, -480, -870, -1222, -1536, -1814, -2056, -2263, -2435, -2576, -2687, -2768, -2822, -2852, -2858, -2843, -2808, -2756, -2688, -2606, -2513, -2409, -2297, -2176, -2050, -1921, -1788, -1653, -1517, -1383, -1248, -1116, -986, -860, -739, -622, -510, -404, -303, -207, -119, -35, 40, 110, 174, 232, 284, 330, 371, 406, 435, 459, 479, 494, 505, 512, 515, 515, 513, 506, 497, 486, 474, 458, 443, 425, 406, 387, 367, 346, 326, 304, 284, 262, 242, 221, 202, 183, 164, 146, 129, 113, 98, 84, 70, 58, 45, 35, 24, 16, 7, 0, -5, -11, -16, -20, -25, -27, -30, -32, -33, -33, -33, -33, -33, -33, -32, -31, -29, -27, -25, -24, -21, -19, -17, -15, -12, -11, -9, -5, -4, -2, 0, 1, 3, 4, 6, 8, 9, 10, 11, 12, 13, 14, 15, 15, 16, 17, 16, 17, 17, 17, 17, 16, 17, 16, 16, 16, 16, 15, 14, 15, 13, 12, 13, 12, 12, 11, 11, 10, 10, 9, 8, 9, 8, 8, 7, 5, 6, 5, 5, 5, 4, 4, 3, 3, 4, 3, 2, 3, 3, 2, 3, 2, 2, 2, 2, 2, 2, 2, 1, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 1, 2, 2, 1, 2, 2, 2, 2, -566, 2565, -17758, -28113, -17054, -11534, -6487, -2362};