/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0893 256 samples */
 
const int16_t AKWF_0893_256_DATA [256] = 
{2977, 8309, 12798, 16474, 19257, 21138, 22154, 22376, 21912, 20895, 19462, 17752, 15904, 14050, 12289, 10710, 9381, 8339, 7602, 7169, 7011, 7095, 7368, 7771, 8242, 8719, 9138, 9450, 9605, 9568, 9317, 8838, 8130, 7211, 6097, 4821, 3425, 1953, 448, -1031, -2440, -3735, -4866, -5804, -6515, -6980, -7186, -7126, -6809, -6244, -5455, -4468, -3315, -2037, -675, 731, 2135, 3494, 4772, 5928, 6929, 7753, 8373, 8777, 8956, 8906, 8633, 8146, 7464, 6603, 5590, 4455, 3225, 1930, 611, -707, -1994, -3216, -4355, -5382, -6277, -7031, -7631, -8068, -8342, -8457, -8416, -8229, -7912, -7476, -6941, -6324, -5650, -4931, -4192, -3453, -2732, -2042, -1401, -821, -314, 116, 463, 724, 896, 987, 998, 935, 807, 622, 390, 123, -167, -472, -783, -1081, -1365, -1626, -1853, -2043, -2192, -2294, -2350, -2361, -2322, -2242, -2124, -1966, -1779, -1565, -1334, -1087, -834, -579, -328, -88, 138, 344, 529, 690, 824, 931, 1009, 1060, 1084, 1084, 1060, 1019, 958, 885, 801, 710, 615, 520, 429, 341, 260, 191, 131, 85, 52, 31, 24, 30, 48, 76, 114, 160, 211, 269, 327, 390, 447, 503, 557, 607, 647, 681, 709, 728, 739, 740, 735, 722, 702, 677, 645, 610, 570, 529, 487, 443, 400, 360, 320, 286, 251, 222, 198, 176, 159, 146, 136, 132, 128, 129, 132, 136, 142, 148, 154, 161, 167, 171, 175, 176, 176, 173, 169, 162, 154, 142, 130, 116, 100, 82, 65, 47, 28, 10, -8, -25, -42, -59, -74, -87, -100, -115, -220, 184, -3586, -18033, -22408, -21239, -26053, -30877, -32537, -32756, -32543, -31188, -28602, -20811, -17439, -12450, -6191, -125};