/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0868 256 samples */
 
const int16_t AKWF_0868_256_DATA [256] = 
{20671, 33146, 28322, 26775, 24769, 22808, 20895, 19040, 17235, 15485, 13798, 12168, 10596, 9093, 7650, 6269, 4958, 3709, 2527, 1413, 364, -616, -1531, -2381, -3164, -3881, -4535, -5124, -5650, -6115, -6520, -6864, -7153, -7383, -7560, -7683, -7757, -7779, -7756, -7688, -7577, -7423, -7234, -7006, -6745, -6453, -6131, -5782, -5409, -5013, -4599, -4168, -3722, -3264, -2797, -2321, -1840, -1358, -875, -394, 82, 553, 1015, 1468, 1908, 2334, 2744, 3138, 3509, 3863, 4193, 4498, 4781, 5034, 5262, 5462, 5634, 5773, 5883, 5962, 6009, 6025, 6008, 5957, 5876, 5761, 5614, 5434, 5222, 4978, 4705, 4400, 4065, 3702, 3309, 2890, 2443, 1972, 1477, 956, 416, -144, -725, -1325, -1942, -2573, -3217, -3874, -4544, -5218, -5903, -6596, -7289, -7987, -8687, -9384, -10081, -10776, -11464, -12146, -12821, -13485, -14141, -14783, -15412, -16028, -15857, -20580, 6991, 26946, 21056, 20044, 18329, 16665, 15055, 13508, 12018, 10587, 9222, 7915, 6672, 5495, 4380, 3331, 2351, 1432, 580, -204, -927, -1583, -2173, -2700, -3166, -3568, -3910, -4191, -4413, -4577, -4686, -4740, -4739, -4689, -4588, -4438, -4244, -4004, -3722, -3402, -3043, -2647, -2218, -1759, -1270, -756, -217, 346, 925, 1525, 2138, 2763, 3401, 4046, 4694, 5349, 6004, 6657, 7308, 7955, 8594, 9224, 9842, 10447, 11039, 11201, 14009, 143, -16156, -12828, -11882, -10641, -9439, -8283, -7181, -6129, -5132, -4191, -3303, -2472, -1701, -987, -331, 264, 801, 1276, 1692, 2049, 2346, 2582, 2760, 2879, 2939, 2941, 2888, 2776, 2611, 2389, 2116, 1789, 1413, 985, 508, -17, -587, -1205, -1863, -2567, -3312, -4095, -4918, -5779, -6671, -7599, -8558, -9538, -10541, -11555, -12565, -13547, -14464, -15252, -15811, -15972, -15454, -13813, -10341, -3329};