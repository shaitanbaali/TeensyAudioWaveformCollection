/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0861 256 samples */
 
const int16_t AKWF_0861_256_DATA [256] = 
{2753, 6411, 6623, 6214, 6842, 8301, 14139, 17253, 19358, 28290, 32455, 26835, 24720, 23855, 22103, 20626, 19206, 17783, 16410, 15079, 13780, 12522, 11305, 10122, 8979, 7875, 6806, 5777, 4790, 3834, 2921, 2047, 1207, 407, -356, -1085, -1774, -2431, -3047, -3626, -4174, -4687, -5162, -5610, -6018, -6392, -6737, -7049, -7326, -7574, -7790, -7978, -8137, -8265, -8364, -8433, -8475, -8494, -8486, -8451, -8389, -8306, -8199, -8066, -7912, -7736, -7543, -7324, -7087, -6830, -6557, -6265, -5954, -5624, -5285, -4928, -4552, -4167, -3767, -3355, -2929, -2492, -2044, -1589, -1119, -642, -160, 334, 834, 1339, 1853, 2371, 2893, 3422, 3954, 4491, 5031, 5570, 6113, 6658, 7201, 7752, 8296, 8840, 9386, 9931, 10471, 11016, 11555, 12089, 12622, 13148, 13676, 14197, 14714, 15224, 15732, 16236, 16733, 17222, 17711, 18212, 18476, 20853, 21121, 10955, 3989, 3195, -2628, -6445, -6618, -6221, -6846, -8301, -14140, -17255, -19357, -28289, -32455, -26835, -24719, -23855, -22103, -20625, -19206, -17783, -16410, -15079, -13780, -12522, -11305, -10123, -8979, -7876, -6807, -5778, -4790, -3834, -2921, -2047, -1208, -408, 355, 1084, 1773, 2430, 3046, 3625, 4174, 4687, 5162, 5609, 6017, 6392, 6737, 7048, 7326, 7574, 7790, 7977, 8137, 8264, 8363, 8432, 8474, 8493, 8485, 8450, 8388, 8306, 8199, 8065, 7912, 7736, 7542, 7323, 7086, 6829, 6556, 6264, 5954, 5623, 5284, 4927, 4551, 4166, 3766, 3353, 2928, 2492, 2043, 1588, 1118, 641, 159, -336, -835, -1340, -1854, -2372, -2894, -3423, -3955, -4492, -5032, -5571, -6114, -6659, -7202, -7753, -8297, -8840, -9387, -9931, -10472, -11016, -11556, -12090, -12623, -13149, -13676, -14198, -14715, -15226, -15733, -16237, -16733, -17223, -17712, -18213, -18476, -20853, -21122, -10967, -4035, -2967};