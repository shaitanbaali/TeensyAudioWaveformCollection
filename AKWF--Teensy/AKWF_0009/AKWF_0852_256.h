/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0852 256 samples */
 
const int16_t AKWF_0852_256_DATA [256] = 
{472, 1237, 1786, 2183, 2550, 2162, 4456, 15708, 18396, 20093, 21430, 22517, 23441, 24245, 24962, 25607, 26192, 26728, 27223, 27678, 28102, 28497, 28863, 29207, 29529, 29828, 30109, 30372, 30618, 30847, 31061, 31260, 31445, 31616, 31775, 31920, 32053, 32174, 32283, 32381, 32467, 32543, 32607, 32660, 32702, 32734, 32732, 32791, 32730, 22877, 18613, 17251, 15906, 14862, 13979, 13206, 12519, 11901, 11333, 10813, 10330, 9880, 9458, 9062, 8687, 8335, 8000, 7681, 7379, 7091, 6816, 6554, 6304, 6063, 5835, 5616, 5406, 5206, 5013, 4829, 4653, 4485, 4324, 4170, 4023, 3883, 3749, 3622, 3501, 3386, 3276, 3173, 3075, 2983, 2897, 2815, 2739, 2669, 2604, 2544, 2488, 2438, 2393, 2353, 2317, 2287, 2262, 2241, 2225, 2214, 2207, 2206, 2205, 2205, 2204, 2201, 2159, 2404, -1750, -4221, -4799, -5440, -5928, -6339, -6696, -7014, -7302, -7564, -7806, -8031, -8240, -8439, -8625, -8801, -8970, -9130, -9282, -9428, -9568, -9703, -9832, -9957, -10079, -10195, -10308, -10417, -10523, -10625, -10725, -10821, -10915, -11007, -11096, -11182, -11266, -11349, -11429, -11507, -11583, -11658, -11730, -11801, -11871, -11939, -12004, -12069, -12132, -12194, -12254, -12314, -12371, -12428, -12484, -12537, -12589, -12642, -12692, -12741, -12790, -12837, -12884, -12930, -12974, -13017, -13060, -13101, -13141, -13181, -13220, -13258, -13295, -13330, -13366, -13401, -13434, -13467, -13500, -13531, -13561, -13591, -13620, -13648, -13676, -13703, -13729, -13754, -13779, -13803, -13826, -13849, -13870, -13892, -13913, -13933, -13952, -13970, -13988, -14006, -14022, -14038, -14054, -14069, -14082, -14096, -14109, -14122, -14134, -14145, -14155, -14165, -14175, -14183, -14191, -14199, -14205, -14212, -14218, -14222, -14228, -14232, -14236, -14238, -14240, -14242, -14243, -14244, -14244, -14243, -14242, -14241, -14205, -14319, -13946, -5047, -1728, -545};