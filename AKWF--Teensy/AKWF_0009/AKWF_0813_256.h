/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0813 256 samples */
 
const int16_t AKWF_0813_256_DATA [256] = 
{5525, 6980, 4871, 6004, 12243, 20356, 25553, 25556, 21778, 17333, 14274, 12369, 10112, 6482, 1861, -2396, -5158, -6306, -6516, -6553, -6660, -6566, -5907, -4638, -3091, -1694, -678, -5, 504, 962, 1322, 1465, 1320, 934, 430, -79, -549, -1000, -1453, -1891, -2271, -2547, -2702, -2752, -2728, -2648, -2516, -2328, -2092, -1821, -1541, -1268, -1011, -772, -553, -356, -189, -56, 42, 111, 153, 175, 178, 164, 134, 95, 49, 1, -47, -94, -140, -183, -221, -253, -280, -301, -317, -328, -334, -337, -336, -330, -322, -313, -301, -287, -271, -254, -236, -218, -199, -180, -159, -139, -118, -97, -77, -58, -39, -20, -2, 15, 32, 48, 63, 76, 89, 101, 112, 120, 129, 136, 143, 147, 150, 153, 156, 157, 156, 156, 154, 151, 149, 146, 142, 137, 134, 128, 124, 119, 114, 108, 102, 98, 92, 87, 81, 77, 72, 67, 64, 60, 56, 53, 50, 46, 44, 41, 39, 38, 37, 36, 34, 33, 33, 32, 33, 34, 35, 36, 38, 39, 39, 41, 42, 43, 45, 48, 50, 51, 53, 54, 56, 59, 61, 63, 64, 66, 67, 69, 71, 72, 74, 75, 77, 77, 79, 80, 80, 81, 82, 84, 84, 84, 85, 84, 85, 85, 84, 84, 84, 83, 83, 82, 81, 80, 80, 79, 78, 77, 76, 75, 74, 73, 72, 70, 69, 67, 65, 64, 63, 62, 60, 59, 56, 55, 53, 52, 50, 49, 47, 45, 43, 42, 40, 39, 37, 35, 33, 32, 30, 28, 27, 26, 24, 22, 19, -10, 17, -604, -6634, -19866, -31430, -31237, -18917, -3502};