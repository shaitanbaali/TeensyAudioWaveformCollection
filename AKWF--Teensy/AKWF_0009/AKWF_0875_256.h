/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0875 256 samples */
 
const int16_t AKWF_0875_256_DATA [256] = 
{172, 717, 1433, 2393, 3555, 4787, 6006, 7305, 8765, 10444, 12266, 14081, 15655, 16815, 17682, 18429, 19246, 20208, 21258, 22322, 23316, 24104, 24756, 25380, 26114, 26729, 26756, 26342, 25932, 26033, 26742, 27818, 28992, 30084, 31063, 31879, 32461, 32747, 32701, 32311, 31587, 30539, 29106, 27365, 25494, 23655, 21950, 20375, 18874, 17394, 15913, 14423, 12912, 11391, 9879, 8387, 6937, 5531, 4158, 2794, 1350, -150, -1678, -3219, -4792, -6452, -8236, -10195, -12192, -14102, -15781, -17184, -18366, -19409, -20390, -21406, -22541, -23663, -24654, -25388, -25767, -25814, -25578, -25141, -24593, -24016, -23461, -22945, -22460, -21983, -21481, -20936, -20337, -19689, -19023, -18396, -17857, -17407, -16991, -16544, -16051, -15441, -14656, -13784, -12885, -12044, -11273, -10515, -9728, -8910, -8077, -7252, -6440, -5630, -4755, -3711, -2581, -1470, -497, 301, 974, 1584, 2174, 2747, 3324, 4024, 4805, 5592, 6294, 6845, 7273, 7638, 7978, 8415, 9122, 10022, 10994, 11880, 12538, 12925, 13133, 13391, 13730, 14143, 14544, 14899, 15314, 15834, 16517, 17239, 17774, 17988, 17822, 17218, 16264, 15130, 13829, 12365, 10708, 8858, 6896, 4959, 3253, 1814, 584, -527, -1595, -2595, -3484, -4221, -4687, -4882, -4921, -4931, -5031, -5233, -5494, -5777, -6062, -6354, -6626, -6767, -6838, -6927, -7140, -7531, -8058, -8657, -9279, -9898, -10503, -11092, -11661, -12204, -12729, -13245, -13750, -14238, -14694, -15101, -15457, -15770, -16040, -16255, -16450, -16637, -16793, -16873, -16815, -16583, -16187, -15669, -15086, -14498, -13948, -13450, -13001, -12578, -12148, -11685, -11145, -10534, -9961, -9391, -8799, -8134, -7361, -6507, -5617, -4727, -3871, -3112, -2607, -2360, -2280, -2232, -2110, -1916, -1708, -1555, -1604, -1849, -2168, -2427, -2515, -2433, -2237, -2079, -2076, -2184, -2293, -2306, -2081, -1547, -912, -333};