/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0831 256 samples */
 
const int16_t AKWF_0831_256_DATA [256] = 
{86, 360, 636, 921, 1216, 1520, 1835, 2161, 2495, 2843, 3201, 3570, 3952, 4343, 4749, 5166, 5592, 6032, 6483, 6945, 7421, 7905, 8400, 8908, 9422, 9947, 10481, 11023, 11572, 12127, 12689, 13255, 13826, 14399, 14974, 15551, 16126, 16701, 17275, 17844, 18408, 18967, 19519, 20065, 20603, 21129, 21647, 22154, 22649, 23132, 23603, 24061, 24506, 24937, 25356, 25761, 26153, 26532, 26903, 27258, 27602, 27938, 28261, 28577, 28884, 29181, 29472, 29755, 30030, 30298, 30560, 30811, 31057, 31294, 31520, 31735, 31937, 32123, 32290, 32438, 32564, 32661, 32730, 32764, 32761, 32718, 32627, 32485, 32290, 32037, 31722, 31340, 30891, 30367, 29771, 29097, 28346, 27517, 26610, 25622, 24560, 23421, 22210, 20931, 19584, 18175, 16716, 15203, 13642, 12048, 10418, 8759, 7085, 5393, 3694, 1998, 304, -1380, -3045, -4695, -6315, -7905, -9465, -10984, -12463, -13901, -15291, -16632, -17928, -19168, -20357, -21493, -22570, -23593, -24563, -25472, -26326, -27123, -27860, -28542, -29166, -29731, -30240, -30694, -31091, -31432, -31720, -31955, -32137, -32269, -32351, -32384, -32372, -32314, -32213, -32072, -31893, -31676, -31423, -31140, -30825, -30484, -30118, -29726, -29315, -28884, -28435, -27974, -27498, -27012, -26517, -26014, -25505, -24995, -24479, -23963, -23446, -22929, -22414, -21904, -21396, -20893, -20397, -19903, -19418, -18941, -18468, -18005, -17548, -17099, -16661, -16231, -15807, -15393, -14990, -14593, -14207, -13827, -13457, -13096, -12744, -12399, -12065, -11737, -11417, -11105, -10800, -10503, -10214, -9930, -9653, -9385, -9120, -8863, -8613, -8366, -8125, -7890, -7659, -7434, -7214, -6996, -6784, -6576, -6371, -6168, -5970, -5773, -5580, -5391, -5201, -5015, -4828, -4644, -4460, -4277, -4095, -3913, -3729, -3545, -3359, -3173, -2984, -2793, -2600, -2403, -2203, -1998, -1789, -1576, -1356, -1133, -901, -665, -420, -163};