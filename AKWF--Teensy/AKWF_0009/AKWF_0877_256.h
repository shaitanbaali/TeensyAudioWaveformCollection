/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0877 256 samples */
 
const int16_t AKWF_0877_256_DATA [256] = 
{4455, 6604, 7971, 9110, 10088, 10956, 11741, 12458, 13120, 13736, 14307, 14841, 15341, 15808, 16245, 16654, 17035, 17392, 17723, 18030, 18314, 18575, 18814, 19032, 19227, 19403, 19558, 19693, 19808, 19904, 19982, 20042, 20083, 20108, 20117, 20110, 20087, 20051, 20002, 19939, 19864, 19779, 19685, 19581, 19468, 19348, 19221, 19089, 18951, 18810, 18663, 18514, 18362, 18210, 18056, 17900, 17745, 17590, 17438, 17289, 17142, 16998, 16860, 16725, 16598, 16478, 16365, 16260, 16165, 16079, 16004, 15939, 15884, 15841, 15808, 15787, 15779, 15781, 15794, 15818, 15854, 15901, 15958, 16026, 16104, 16190, 16285, 16389, 16499, 16618, 16743, 16874, 17011, 17152, 17300, 17451, 17606, 17762, 17920, 18080, 18241, 18403, 18564, 18723, 18881, 19036, 19188, 19336, 19479, 19616, 19747, 19871, 19989, 20098, 20197, 20287, 20367, 20436, 20493, 20539, 20570, 20590, 20594, 20584, 20559, 20517, 20461, 20388, 20297, 20190, 20064, 19920, 19757, 19575, 19374, 19153, 18913, 18652, 18370, 18066, 17741, 17394, 17023, 16627, 16208, 15760, 15285, 14780, 14242, 13668, 13056, 12396, 11684, 10910, 10052, 9089, 7966, 6610, 4722, -2395, -6124, -7473, -8817, -9947, -10964, -11904, -12789, -13627, -14429, -15202, -15946, -16671, -17376, -18060, -18730, -19386, -20025, -20653, -21268, -21868, -22459, -23038, -23604, -24160, -24705, -25238, -25762, -26274, -26774, -27265, -27744, -28210, -28667, -29111, -29542, -29962, -30368, -30760, -31140, -31505, -31860, -32202, -32584, -32780, -32764, -32767, -32767, -32767, -32767, -32767, -32767, -32764, -32779, -32676, -32309, -31950, -31587, -31210, -30816, -30405, -29980, -29537, -29081, -28612, -28128, -27632, -27126, -26609, -26083, -25546, -24998, -24442, -23877, -23299, -22713, -22115, -21505, -20886, -20253, -19606, -18948, -18272, -17580, -16873, -16142, -15390, -14613, -13803, -12958, -12070, -11121, -10098, -8968, -7653, -6159, -3112};