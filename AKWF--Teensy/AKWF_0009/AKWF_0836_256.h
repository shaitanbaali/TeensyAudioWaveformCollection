/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0836 256 samples */
 
const int16_t AKWF_0836_256_DATA [256] = 
{540, 2435, 4229, 5967, 7647, 9271, 10838, 12347, 13803, 15209, 16560, 17862, 19116, 20320, 21480, 22594, 23661, 24689, 25673, 26617, 27523, 28389, 29218, 30011, 30775, 31520, 32202, 32551, 32677, 32748, 32768, 32748, 32699, 32624, 32531, 32418, 32293, 32155, 32007, 31850, 31687, 31516, 31341, 31163, 30981, 30796, 30611, 30423, 30236, 30047, 29860, 29674, 29488, 29304, 29121, 28940, 28761, 28585, 28412, 28240, 28072, 27902, 27755, 27460, 26529, 25393, 24328, 23300, 22316, 21372, 20466, 19598, 18767, 17970, 17207, 16475, 15775, 15105, 14461, 13851, 13224, 12483, 11724, 10979, 10247, 9534, 8841, 8165, 7511, 6879, 6265, 5672, 5100, 4548, 4013, 3499, 3001, 2522, 2062, 1616, 1189, 777, 381, 2, -364, -716, -1054, -1377, -1689, -1985, -2271, -2546, -2804, -3100, -3480, -3872, -4265, -4651, -5030, -5401, -5764, -6119, -6462, -6796, -7121, -7437, -7743, -8038, -8326, -8604, -8874, -9136, -9388, -9633, -9871, -10099, -10320, -10535, -10742, -10942, -11136, -11323, -11504, -11679, -11847, -12012, -12171, -12322, -12470, -12613, -12751, -12883, -13011, -13136, -13258, -13374, -13485, -13594, -13698, -13800, -13898, -13992, -14082, -14171, -14255, -14337, -14416, -14493, -14568, -14639, -14707, -14773, -14837, -14900, -14959, -15017, -15072, -15125, -15176, -15226, -15274, -15320, -15365, -15406, -15448, -15487, -15524, -15561, -15596, -15628, -15661, -15692, -15722, -15749, -15777, -15802, -15826, -15850, -15871, -15894, -15913, -15932, -15950, -15967, -15982, -15998, -15979, -15914, -15840, -15762, -15681, -15603, -15519, -15466, -15677, -16050, -16449, -16869, -17305, -17743, -18184, -18626, -19062, -19494, -19921, -20340, -20749, -21151, -21542, -21924, -22294, -22654, -23002, -23340, -23665, -23978, -24280, -24569, -24846, -25118, -25390, -25650, -25900, -26133, -25525, -23606, -21241, -18859, -16492, -14168, -11885, -9659, -7494, -5388, -3348, -1332};