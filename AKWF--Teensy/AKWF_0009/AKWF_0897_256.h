/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0897 256 samples */
 
const int16_t AKWF_0897_256_DATA [256] = 
{530, 2329, 4080, 5815, 7526, 9214, 10875, 12496, 14079, 15619, 17101, 18530, 19892, 21184, 22402, 23541, 24595, 25566, 26449, 27242, 27949, 28570, 29106, 29565, 29948, 30259, 30508, 30699, 30838, 30935, 30995, 31026, 31035, 31027, 31010, 30989, 30967, 30951, 30945, 30948, 30965, 30996, 31044, 31104, 31182, 31269, 31370, 31480, 31596, 31719, 31842, 31965, 32086, 32203, 32310, 32411, 32498, 32577, 32641, 32692, 32730, 32757, 32766, 32766, 32755, 32734, 32705, 32670, 32627, 32581, 32534, 32485, 32438, 32392, 32350, 32312, 32279, 32252, 32231, 32217, 32209, 32207, 32212, 32221, 32236, 32255, 32278, 32304, 32331, 32359, 32388, 32415, 32443, 32467, 32490, 32510, 32526, 32539, 32548, 32554, 32554, 32562, 32464, 32312, 32130, 31815, 31419, 30909, 30284, 29542, 28670, 27671, 26552, 25311, 23959, 22504, 20951, 19192, 17402, 15767, 13991, 12175, 10339, 8503, 6673, 4847, 3035, 1237, -555, -2323, -4078, -5815, -7527, -9214, -10875, -12496, -14080, -15620, -17101, -18529, -19892, -21184, -22402, -23541, -24595, -25566, -26449, -27242, -27949, -28571, -29106, -29565, -29949, -30259, -30508, -30699, -30838, -30935, -30995, -31026, -31035, -31027, -31010, -30989, -30967, -30952, -30945, -30948, -30966, -30997, -31045, -31104, -31182, -31269, -31370, -31480, -31596, -31719, -31842, -31965, -32086, -32203, -32309, -32411, -32498, -32577, -32641, -32691, -32730, -32756, -32766, -32766, -32755, -32734, -32704, -32670, -32627, -32581, -32533, -32485, -32437, -32392, -32350, -32312, -32279, -32252, -32231, -32217, -32209, -32208, -32211, -32221, -32236, -32255, -32278, -32303, -32331, -32359, -32388, -32416, -32443, -32468, -32490, -32510, -32526, -32538, -32549, -32553, -32555, -32563, -32464, -32312, -32130, -31814, -31420, -30908, -30285, -29541, -28670, -27671, -26552, -25311, -23960, -22505, -20951, -19192, -17402, -15768, -13990, -12175, -10339, -8504, -6674, -4851, -3043, -1214};