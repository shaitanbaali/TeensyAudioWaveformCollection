/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0879 256 samples */
 
const int16_t AKWF_0879_256_DATA [256] = 
{4697, 7055, 8481, 9654, 10647, 11522, 12309, 13028, 13694, 14316, 14902, 15459, 15991, 16499, 16990, 17467, 17929, 18381, 18823, 19257, 19685, 20108, 20525, 20941, 21355, 21765, 22176, 22586, 23000, 23335, 23594, 23775, 23871, 23923, 23946, 23972, 24026, 24119, 24252, 24413, 24596, 24791, 24991, 25191, 25389, 25585, 25774, 25960, 26140, 26323, 26461, 26504, 26486, 26370, 26199, 25987, 25759, 25548, 25366, 25221, 25103, 25006, 24922, 24845, 24770, 24693, 24614, 24532, 24445, 24356, 24267, 24167, 23965, 23703, 23339, 22900, 22411, 21894, 21381, 20897, 20453, 20044, 19666, 19309, 18962, 18626, 18294, 17963, 17634, 17306, 16978, 16655, 16337, 16024, 15721, 15430, 15152, 14891, 14649, 14430, 14238, 14072, 13937, 13837, 13773, 13747, 13761, 13815, 13911, 14049, 14228, 14448, 14704, 15008, 15283, 15454, 15574, 15583, 15550, 15499, 15465, 15494, 15609, 15809, 16083, 16414, 16785, 17184, 17604, 18037, 18478, 18928, 19383, 19840, 20310, 20752, 20894, 20870, 20554, 20023, 19345, 18573, 17804, 17114, 16534, 16059, 15664, 15317, 14988, 14655, 14300, 13908, 13470, 12978, 12421, 11788, 11084, 10070, 8613, 6838, -1741, -8370, -10096, -12003, -13503, -14790, -15924, -16945, -17887, -18772, -19609, -20413, -21189, -21936, -22661, -23365, -24046, -24705, -25340, -25952, -26542, -27108, -27647, -28162, -28649, -29108, -29539, -29941, -30312, -30651, -30958, -31233, -31472, -31678, -31847, -31981, -32077, -32136, -32155, -32145, -32185, -32237, -32337, -32462, -32587, -32695, -32760, -32759, -32690, -32558, -32367, -32129, -31850, -31534, -31186, -30808, -30403, -29971, -29510, -29024, -28505, -28031, -27601, -27219, -26896, -26595, -26303, -25990, -25630, -25213, -24738, -24212, -23642, -23035, -22398, -21728, -21032, -20308, -19554, -18767, -17947, -17072, -16207, -15431, -14701, -14090, -13542, -13032, -12519, -11945, -11260, -10439, -9449, -8228, -6746, -3871};