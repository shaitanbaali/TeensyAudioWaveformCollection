/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0841 256 samples */
 
const int16_t AKWF_0841_256_DATA [256] = 
{3, 27, 77, 156, 265, 407, 583, 793, 1038, 1318, 1633, 1984, 2371, 2790, 3246, 3734, 4254, 4806, 5389, 6000, 6640, 7307, 7997, 8712, 9448, 10202, 10977, 11765, 12566, 13381, 14206, 15036, 15872, 16710, 17549, 18388, 19219, 20047, 20866, 21672, 22466, 23245, 24005, 24746, 25467, 26160, 26830, 27473, 28084, 28665, 29214, 29725, 30203, 30643, 31044, 31406, 31727, 32006, 32243, 32436, 32585, 32690, 32751, 32768, 32740, 32656, 32506, 32283, 31986, 31612, 31158, 30626, 30017, 29332, 28575, 27747, 26850, 25894, 24878, 23810, 22698, 21544, 20355, 19144, 17910, 16664, 15415, 14167, 12929, 11712, 10517, 9357, 8238, 7162, 6144, 5186, 4292, 3472, 2729, 2066, 1491, 1006, 612, 315, 113, 14, -2, 0, -5, -69, -241, -530, -942, -1478, -2135, -2905, -3785, -4757, -5809, -6930, -8097, -9293, -10502, -11701, -12869, -13994, -15048, -16019, -16890, -17643, -18269, -18756, -19096, -19280, -19320, -19314, -19309, -19300, -19286, -19268, -19244, -19215, -19181, -19142, -19097, -19047, -18992, -18930, -18862, -18789, -18710, -18625, -18534, -18437, -18334, -18226, -18112, -17991, -17866, -17735, -17596, -17453, -17304, -17150, -16991, -16825, -16654, -16479, -16298, -16112, -15922, -15727, -15527, -15323, -15114, -14900, -14684, -14462, -14237, -14009, -13777, -13542, -13305, -13063, -12819, -12572, -12323, -12071, -11818, -11563, -11306, -11047, -10787, -10527, -10266, -10003, -9740, -9476, -9213, -8951, -8688, -8425, -8163, -7903, -7643, -7386, -7129, -6873, -6621, -6370, -6121, -5876, -5632, -5392, -5155, -4921, -4690, -4464, -4241, -4022, -3808, -3597, -3392, -3191, -2995, -2804, -2618, -2437, -2262, -2094, -1930, -1772, -1621, -1475, -1336, -1203, -1077, -957, -844, -738, -638, -546, -460, -383, -311, -247, -191, -141, -99, -65, -37, -17, -4, 0, -1, -1};