/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0815 256 samples */
 
const int16_t AKWF_0815_256_DATA [256] = 
{1440, 4971, 8197, 11183, 13898, 16332, 18479, 20329, 21893, 23176, 24181, 24921, 25412, 25664, 25697, 25528, 25172, 24646, 23969, 23159, 22228, 21198, 20086, 18901, 17660, 16381, 15069, 13742, 12410, 11081, 9766, 8475, 7211, 5985, 4803, 3666, 2584, 1563, 601, -318, 1021, 5398, 10859, 16293, 21025, 24683, 27135, 28366, 28447, 27507, 25693, 23166, 20068, 16554, 12762, 8794, 4766, 770, -3137, -6881, -10413, -13712, -16732, -19454, -21878, -23981, -25774, -27257, -28436, -29322, -29929, -30269, -30362, -30224, -29872, -29326, -28603, -27727, -26710, -25571, -24337, -23016, -21627, -20186, -18705, -17201, -15689, -14173, -12668, -11188, -9735, -8321, -6954, -5634, -4373, -3175, -2038, -969, 26, 855, 1502, 2043, 2520, 2960, 3376, 3776, 4161, 4529, 4880, 5208, 5508, 5778, 6019, 6229, 6402, 6539, 6640, 6703, 6733, 6728, 6690, 6620, 6523, 6402, 6255, 6087, 5899, 5693, 5473, 5240, 4998, 4747, 4492, 4234, 3985, 3733, 3476, 3216, 2961, 2709, 2464, 2227, 1997, 1776, 1564, 1365, 1177, 1002, 837, 684, 544, 414, 294, 186, 88, 3, -74, -143, -201, -248, -290, -325, -351, -374, -388, -398, -402, -399, -392, -383, -369, -353, -337, -317, -296, -273, -248, -222, -196, -171, -145, -118, -93, -66, -42, -19, 3, 24, 44, 63, 80, 96, 112, 125, 136, 148, 157, 166, 173, 179, 183, 187, 190, 193, 193, 193, 192, 190, 188, 185, 180, 176, 172, 167, 162, 158, 151, 144, 137, 131, 125, 118, 111, 106, 99, 93, 87, 83, 78, 73, 67, 61, 57, 55, 33, 74, -251, -3366, -8800, -14809, -20477, -25287, -28954, -31376, -32589, -32678, -31776, -30024, -27582, -24605, -21219, -17557, -13735, -9842, -5974, -2117};