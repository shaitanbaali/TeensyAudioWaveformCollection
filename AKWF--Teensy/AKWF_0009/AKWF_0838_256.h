/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0838 256 samples */
 
const int16_t AKWF_0838_256_DATA [256] = 
{1006, 3344, 5618, 7866, 10069, 12214, 14294, 16290, 18198, 20007, 21703, 23291, 24760, 26101, 27316, 28404, 29362, 30196, 30902, 31486, 31952, 32307, 32556, 32708, 32767, 32743, 32645, 32481, 32260, 31992, 31684, 31345, 30980, 30601, 30214, 29822, 29436, 29058, 28691, 28342, 28012, 27702, 27416, 27154, 26916, 26702, 26510, 26342, 26196, 26065, 25950, 25851, 25766, 25690, 25623, 25563, 25505, 25449, 25394, 25339, 25283, 25225, 25165, 25099, 25028, 24953, 24873, 24787, 24699, 24606, 24507, 24404, 24296, 24182, 24063, 23938, 23806, 23665, 23516, 23357, 23186, 23001, 22802, 22588, 22353, 22099, 21822, 21523, 21200, 20850, 20473, 20067, 19634, 19171, 18680, 18160, 17613, 17043, 16446, 15826, 15188, 14532, 13860, 13179, 12488, 11791, 11095, 10399, 9707, 9027, 8358, 7702, 7062, 6442, 5843, 5268, 4713, 4183, 3677, 3194, 2733, 2294, 1873, 1471, 1084, 707, 339, -23, -381, -740, -1106, -1479, -1859, -2254, -2668, -3098, -3548, -4021, -4514, -5033, -5575, -6140, -6726, -7335, -7963, -8609, -9270, -9942, -10625, -11313, -12003, -12695, -13383, -14062, -14731, -15387, -16026, -16647, -17244, -17817, -18366, -18887, -19381, -19845, -20280, -20687, -21067, -21417, -21741, -22040, -22313, -22564, -22794, -23006, -23199, -23377, -23543, -23695, -23833, -23964, -24088, -24203, -24311, -24415, -24513, -24604, -24691, -24774, -24851, -24924, -24993, -25058, -25118, -25170, -25220, -25267, -25311, -25353, -25395, -25435, -25478, -25524, -25575, -25633, -25701, -25782, -25874, -25983, -26109, -26256, -26424, -26614, -26828, -27067, -27328, -27614, -27921, -28248, -28594, -28954, -29323, -29699, -30074, -30442, -30798, -31134, -31441, -31713, -31939, -32112, -32225, -32265, -32225, -32098, -31878, -31554, -31120, -30571, -29903, -29110, -28193, -27146, -25972, -24673, -23246, -21699, -20040, -18266, -16392, -14427, -12372, -10248, -8065, -5831, -3568, -1234};