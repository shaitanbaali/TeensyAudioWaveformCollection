/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0849 256 samples */
 
const int16_t AKWF_0849_256_DATA [256] = 
{20254, 20254, 20253, 20253, 20250, 20248, 20246, 20244, 20241, 20237, 20234, 20231, 20227, 20224, 20219, 20216, 20211, 20207, 20202, 20198, 20194, 20189, 20184, 20179, 20174, 20169, 20164, 20159, 20154, 20149, 20145, 20139, 20134, 20129, 20124, 20118, 20113, 20108, 20103, 20097, 20092, 20087, 20082, 20077, 20071, 20066, 20060, 20055, 20050, 20044, 20039, 20034, 20028, 20023, 20018, 20013, 20007, 20002, 19997, 19991, 19985, 19850, 20484, 18127, -10148, -12503, -11867, -12001, -12003, -12005, -12007, -12008, -12007, -12007, -12007, -12008, -12007, -12006, -12006, -12004, -12003, -12001, -11999, -11998, -11996, -12375, -10335, -23094, -34396, -32388, -32758, -32754, -32749, -32744, -32739, -32732, -32726, -32720, -32714, -32707, -32700, -32693, -32686, -32679, -32672, -32664, -32656, -32648, -32640, -32632, -32624, -32616, -32254, -34232, -25262, 588, -1134, -835, -823, -817, -812, -807, -804, -800, -796, -793, -791, -788, -786, -783, -781, -780, -778, -776, -775, -773, -772, -772, -770, -769, -768, -768, -767, -765, -765, -764, -764, -763, -764, -762, -761, -762, -761, -760, -761, -760, -759, -759, -760, -759, -757, -758, -757, -758, -757, -756, -757, -756, -757, -756, -755, -756, -755, -756, -755, -754, -753, -754, -753, -754, -753, -753, -752, -753, -752, -752, -753, -752, -751, -752, -751, -751, -752, -751, -749, -750, -749, -749, -749, -750, -749, -748, -749, -748, -748, -749, -748, -748, -747, -748, -747, -747, -748, -747, -745, -746, -746, -745, -745, -746, -745, -744, -745, -744, -744, -745, -744, -744, -743, -744, -743, -743, -744, -743, -741, -742, -742, -741, -741, -742, -741, -740, -741, -740, -740, -741, -740, -740, -739, -740, -739, -739, -740, -1007, 437, -7300};