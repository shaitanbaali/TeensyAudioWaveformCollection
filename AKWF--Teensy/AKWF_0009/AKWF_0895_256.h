/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0895 256 samples */
 
const int16_t AKWF_0895_256_DATA [256] = 
{272, 1683, 7037, 5414, 6534, 8054, 9377, 10555, 11601, 12536, 13373, 14131, 14821, 15453, 16039, 16582, 17089, 17566, 18014, 18434, 18829, 19199, 19545, 19866, 20161, 20431, 20675, 20892, 21084, 21249, 21389, 21503, 21595, 21664, 21711, 21740, 21752, 21748, 21733, 21707, 21673, 21633, 21590, 21546, 21503, 21462, 21424, 21391, 21364, 21344, 21330, 21324, 21326, 21334, 21348, 21368, 21394, 21424, 21457, 21492, 21529, 21565, 21602, 21636, 21669, 21699, 21724, 21746, 21764, 21778, 21786, 21791, 21791, 21787, 21779, 21768, 21755, 21739, 21722, 21704, 21685, 21667, 21649, 21632, 21617, 21603, 21592, 21582, 21575, 21570, 21568, 21568, 21570, 21574, 21580, 21488, 22094, 19198, 17570, 19852, 18818, 18173, 17587, 17090, 16664, 16293, 15966, 15635, 15634, 14199, 5519, 10570, 9351, 7590, 6058, 4694, 3514, 2345, -3138, -1732, -2691, -4300, -5745, -6828, -8985, -14022, -12320, -13989, -15673, -17222, -18647, -19962, -21175, -22305, -23362, -24349, -25276, -26145, -26956, -27712, -28415, -29060, -29652, -30188, -30666, -31090, -31457, -31770, -32030, -32240, -32401, -32517, -32593, -32632, -32638, -32617, -32573, -32511, -32435, -32353, -32265, -32177, -32092, -32014, -31946, -31890, -31846, -31816, -31801, -31801, -31815, -31842, -31882, -31933, -31993, -32059, -32130, -32206, -32282, -32357, -32429, -32498, -32561, -32616, -32663, -32702, -32732, -32752, -32764, -32766, -32760, -32745, -32725, -32700, -32668, -32633, -32597, -32559, -32520, -32483, -32448, -32416, -32387, -32362, -32341, -32326, -32315, -32309, -32308, -32311, -32318, -32329, -32344, -32360, -32379, -32399, -32420, -32441, -32462, -32482, -32500, -32516, -32530, -32443, -33050, -30150, -28517, -30790, -29744, -29085, -28485, -27970, -27513, -27240, -22336, -24085, -23901, -22786, -21878, -21068, -15784, -17295, -16656, -15238, -14023, -12911, -11893, -10948, -10004, -9565, -6984, -3142, -5124, -3483, -2107, -800};