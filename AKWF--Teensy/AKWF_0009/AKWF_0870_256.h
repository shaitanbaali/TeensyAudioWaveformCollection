/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0870 256 samples */
 
const int16_t AKWF_0870_256_DATA [256] = 
{1167, 4291, 7259, 10148, 12950, 15670, 18314, 20872, 23357, 25770, 28077, 30437, 32258, 28896, 24415, 20336, 16355, 12502, 8787, 5216, 1765, -1551, -4738, -7809, -10755, -13543, -16438, -17670, -16800, -16096, -15367, -14636, -13906, -13180, -12458, -11741, -11031, -10328, -9634, -8951, -8278, -7616, -6967, -6331, -5710, -5105, -4514, -3940, -3385, -2846, -2327, -1827, -1345, -883, -441, -20, 380, 758, 1118, 1456, 1770, 2065, 2338, 2589, 2820, 3029, 3217, 3386, 3534, 3661, 3769, 3858, 3927, 3979, 4012, 4028, 4028, 4010, 3978, 3929, 3867, 3791, 3701, 3601, 3488, 3364, 3230, 3086, 2934, 2774, 2608, 2435, 2256, 2072, 1884, 1692, 1499, 1302, 1108, 909, 713, 517, 322, 130, -59, -245, -427, -602, -774, -941, -1100, -1255, -1401, -1540, -1672, -1794, -1910, -2016, -2113, -2202, -2281, -2351, -2410, -2460, -2500, -2531, -2553, -2565, -2567, -2559, -2536, -2505, -2466, -2419, -2365, -2303, -2233, -2158, -2075, -1985, -1889, -1788, -1681, -1570, -1453, -1326, -1196, -1061, -923, -782, -639, -494, -346, -200, -50, 98, 245, 393, 537, 682, 822, 961, 1097, 1227, 1355, 1478, 1596, 1708, 1815, 1917, 2010, 2099, 2180, 2252, 2319, 2376, 2427, 2470, 2503, 2528, 2545, 2553, 2553, 2542, 2525, 2497, 2461, 2416, 2361, 2299, 2227, 2148, 2059, 1964, 1861, 1748, 1629, 1502, 1367, 1227, 1079, 927, 768, 602, 433, 258, 79, -104, -291, -479, -673, -868, -1066, -1265, -1464, -1667, -1867, -2067, -2269, -2469, -2667, -2864, -3059, -3251, -3439, -3625, -3808, -3985, -4160, -4328, -4492, -4648, -4801, -4949, -5088, -5223, -5350, -5470, -5583, -5688, -5786, -5876, -5957, -6032, -6098, -6156, -6206, -6247, -6282, -6304, -6288, -6451, -4732, -781, -3124, -2349};