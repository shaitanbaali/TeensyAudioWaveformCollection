/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0900 256 samples */
 
const int16_t AKWF_0900_256_DATA [256] = 
{189, 544, 857, 1139, 1390, 1611, 1802, 1967, 2108, 2229, 2332, 2423, 2506, 2583, 2660, 2740, 2826, 2922, 3031, 3154, 3294, 3453, 3629, 3826, 4042, 4275, 4528, 4796, 5078, 5372, 5677, 5990, 6308, 6629, 6951, 7271, 7588, 7899, 8202, 8497, 8782, 9057, 9320, 9571, 9813, 10041, 10260, 10470, 10670, 10864, 11052, 11235, 11415, 11593, 11771, 11950, 12130, 12315, 12503, 12697, 12896, 13102, 13315, 13533, 13759, 13991, 14228, 14471, 14718, 14970, 15226, 15483, 15743, 16004, 16264, 16524, 16783, 17039, 17294, 17545, 17792, 18038, 18278, 18516, 18749, 18980, 19206, 19430, 19651, 19870, 20087, 20302, 20517, 20732, 20946, 21160, 21376, 21593, 21810, 22030, 22251, 22474, 22699, 22927, 23156, 23387, 23620, 23853, 24090, 24327, 24565, 24802, 25031, 25244, 25429, 25570, 25650, 25646, 25538, 25297, 24899, 24316, 23525, 22506, 21241, 19717, 17933, 15891, 13594, 11071, 8339, 5426, 2380, -763, -3963, -7160, -10317, -13389, -16318, -19080, -21637, -23949, -26008, -27794, -29294, -30516, -31459, -32133, -32558, -32751, -32736, -32537, -32178, -31688, -31086, -30401, -29650, -28848, -28017, -27167, -26303, -25440, -24580, -23724, -22880, -22045, -21220, -20412, -19620, -18844, -18093, -17369, -16677, -16028, -15427, -14880, -14400, -13990, -13658, -13412, -13253, -13185, -13209, -13321, -13517, -13789, -14132, -14528, -14969, -15438, -15920, -16396, -16854, -17274, -17641, -17941, -18163, -18295, -18329, -18261, -18087, -17809, -17427, -16948, -16383, -15738, -15026, -14263, -13463, -12638, -11807, -10986, -10185, -9421, -8707, -8051, -7463, -6952, -6516, -6164, -5892, -5700, -5582, -5534, -5548, -5616, -5727, -5871, -6039, -6219, -6400, -6571, -6723, -6849, -6938, -6988, -6991, -6944, -6845, -6693, -6488, -6234, -5930, -5584, -5199, -4781, -4336, -3870, -3392, -2906, -2419, -1939, -1470, -1018, -588, -177};