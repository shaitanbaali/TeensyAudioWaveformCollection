/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0810 256 samples */
 
const int16_t AKWF_0810_256_DATA [256] = 
{1175, 3561, 4573, 4030, 2858, 2527, 3081, 3567, 3703, 3885, 3974, 4160, 5599, 9470, 15353, 21598, 26922, 30876, 32595, 31640, 29040, 26212, 23176, 19186, 14017, 8174, 1823, -4723, -10118, -12825, -13161, -12556, -11971, -11836, -12840, -15222, -18033, -19791, -20435, -20910, -21488, -21771, -21891, -21658, -19920, -15502, -8827, -1556, 5012, 10423, 13792, 14661, 14047, 13340, 12536, 10875, 8103, 4696, 807, -3286, -6259, -6594, -4640, -1849, 803, 2857, 3608, 2804, 1367, 772, 1068, 1300, 1188, 1125, 978, 934, 2148, 5803, 11478, 17526, 22662, 26437, 27986, 26874, 24127, 21165, 18007, 13905, 8639, 2711, -3713, -10317, -15758, -18497, -18853, -18253, -17660, -17505, -18471, -20804, -23553, -25234, -25791, -26164, -26628, -26784, -26766, -26383, -24482, -19891, -13033, -5567, 1205, 6831, 10422, 11521, 11144, 10683, 10132, 8730, 6221, 3083, -532, -4348, -7043, -7095, -4859, -1783, 1152, 3490, 4525, 4000, 2841, 2523, 3093, 3592, 3742, 3936, 4038, 4239, 5691, 9575, 15469, 21728, 27066, 31033, 32763, 31822, 29235, 26418, 23396, 19418, 14262, 8430, 2090, -4445, -9828, -12524, -12849, -12233, -11637, -11492, -12484, -14856, -17658, -19405, -20042, -20507, -21076, -21351, -21461, -21219, -19473, -15048, -8367, -1089, 5486, 10903, 14279, 15154, 14544, 13843, 13044, 11388, 8622, 5219, 1334, -2755, -5725, -6058, -4102, -1308, 1345, 3400, 4152, 3347, 1910, 1318, 1614, 1845, 1732, 1668, 1518, 1472, 2685, 6338, 12011, 18056, 23188, 26960, 28506, 27391, 24639, 21671, 18507, 14400, 9129, 3195, -3235, -9848, -15296, -18043, -18406, -17813, -17228, -17080, -18056, -20398, -23155, -24846, -25413, -25797, -26271, -26437, -26427, -26055, -24164, -19585, -12739, -5284, 1477, 7090, 10669, 11755, 11367, 10894, 10330, 8914, 6394, 3244, -384, -4212, -6921, -6991, -4774, -1658};