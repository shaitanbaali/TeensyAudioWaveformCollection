/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0827 256 samples */
 
const int16_t AKWF_0827_256_DATA [256] = 
{150, 431, 708, 985, 1263, 1541, 1818, 2095, 2373, 2651, 2929, 3206, 3485, 3761, 4039, 4316, 4595, 4872, 5150, 5426, 5706, 5983, 6260, 6538, 6816, 7093, 7371, 7649, 7926, 8204, 8481, 8759, 9037, 9314, 9591, 9870, 10148, 10424, 10702, 10980, 11258, 11535, 11813, 12091, 12369, 12645, 12923, 13202, 13479, 13756, 14034, 14312, 14590, 14867, 15145, 15423, 15700, 15977, 16256, 16533, 16810, 17088, 17366, 17643, 17921, 18198, 18477, 18754, 19031, 19309, 19588, 19865, 20142, 20420, 20698, 20975, 21252, 21530, 21808, 22086, 22363, 22640, 22919, 23196, 23473, 23751, 24029, 24307, 24584, 24861, 25140, 25417, 25694, 25972, 26250, 26527, 26805, 27083, 27361, 27639, 27915, 28193, 28471, 28749, 29026, 29305, 29582, 29859, 30136, 30415, 30692, 30970, 31247, 31526, 31803, 32080, 32346, 32651, 32685, 30913, 27307, 22717, 17631, 12428, 7351, 2533, -1914, -5952, -9575, -12774, -15576, -18012, -20099, -21881, -23390, -24648, -25694, -26552, -27243, -27794, -28222, -28542, -28773, -28926, -29012, -29042, -29023, -28965, -28871, -28748, -28602, -28433, -28248, -28048, -27834, -27611, -27379, -27139, -26894, -26643, -26387, -26128, -25866, -25600, -25333, -25066, -24795, -24525, -24251, -23977, -23703, -23429, -23155, -22879, -22603, -22327, -22051, -21774, -21497, -21221, -20943, -20666, -20389, -20112, -19834, -19557, -19280, -19002, -18724, -18446, -18170, -17892, -17615, -17337, -17059, -16781, -16505, -16226, -15948, -15671, -15394, -15115, -14838, -14561, -14284, -14006, -13728, -13450, -13173, -12895, -12617, -12340, -12063, -11784, -11507, -11229, -10952, -10674, -10396, -10119, -9842, -9563, -9286, -9009, -8731, -8453, -8176, -7898, -7620, -7342, -7065, -6788, -6510, -6231, -5954, -5677, -5399, -5121, -4844, -4567, -4289, -4010, -3733, -3457, -3178, -2900, -2623, -2346, -2067, -1790, -1512, -1235, -957, -680, -403, -121};