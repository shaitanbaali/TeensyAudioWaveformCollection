/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0885 256 samples */
 
const int16_t AKWF_0885_256_DATA [256] = 
{596, 2336, 4002, 5633, 7215, 8748, 10230, 11650, 13014, 14319, 15560, 16742, 17864, 18922, 19923, 20865, 21747, 22575, 23347, 24066, 24736, 25355, 25927, 26455, 26939, 27381, 27785, 28151, 28481, 28778, 29042, 29277, 29483, 29662, 29815, 29945, 30051, 30138, 30204, 30252, 30283, 30298, 30297, 30283, 30256, 30215, 30163, 30099, 30024, 29938, 29831, 29691, 29505, 29266, 28964, 28592, 28142, 27614, 27000, 26301, 25514, 24637, 23674, 22623, 21483, 20263, 18960, 17575, 16118, 14586, 12982, 11318, 9601, 7847, 6078, 4299, 2524, 766, -971, -2677, -4341, -5968, -7546, -9068, -10540, -11954, -13307, -14604, -15839, -17013, -18128, -19183, -20177, -21117, -21999, -22826, -23601, -24325, -24998, -25627, -26207, -26746, -27246, -27705, -28128, -28517, -28873, -29198, -29496, -29766, -30011, -30235, -30436, -30617, -30780, -30926, -31058, -31176, -31280, -31374, -31456, -31528, -31592, -31649, -31699, -31743, -31782, -31815, -31845, -31871, -31894, -31915, -31934, -31950, -31966, -31981, -31993, -32006, -32019, -32030, -32043, -32054, -32067, -32080, -32092, -32105, -32119, -32133, -32148, -32163, -32178, -32195, -32213, -32230, -32248, -32266, -32286, -32306, -32325, -32346, -32367, -32388, -32410, -32431, -32454, -32477, -32500, -32522, -32545, -32568, -32591, -32614, -32636, -32657, -32677, -32696, -32714, -32729, -32742, -32752, -32760, -32765, -32767, -32767, -32763, -32756, -32746, -32733, -32715, -32696, -32673, -32647, -32617, -32585, -32549, -32511, -32470, -32426, -32379, -32330, -32277, -32223, -32166, -32106, -32044, -31980, -31913, -31844, -31773, -31699, -31623, -31545, -31464, -31382, -31298, -31210, -31120, -31029, -30934, -30837, -30738, -30634, -30528, -30419, -30307, -30191, -30072, -29947, -29815, -29659, -29466, -29227, -28930, -28566, -28131, -27617, -27022, -26343, -25576, -24721, -23782, -22752, -21637, -20440, -19159, -17798, -16364, -14852, -13271, -11626, -9923, -8183, -6423, -4651, -2885, -1095};