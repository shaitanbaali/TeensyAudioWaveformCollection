/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0864 256 samples */
 
const int16_t AKWF_0864_256_DATA [256] = 
{1209, 3839, 6287, 8598, 10746, 12719, 14504, 16077, 17439, 18580, 19486, 20159, 20595, 20794, 20752, 20497, 20178, 19856, 19523, 19184, 18835, 18480, 18119, 17750, 17376, 16997, 16611, 16222, 15829, 15430, 15029, 14625, 14217, 13809, 13397, 12985, 12572, 12157, 11743, 11328, 10912, 10498, 10086, 9674, 9264, 8856, 8450, 8047, 7646, 7249, 6855, 6466, 6079, 5696, 5319, 4945, 4577, 4215, 3857, 3503, 3155, 2822, 2074, 788, -782, -2558, -4492, -6543, -8666, -10836, -13022, -15191, -17325, -19398, -21378, -23256, -25009, -26613, -28060, -29334, -30418, -31309, -31993, -32463, -32719, -32756, -32573, -32187, -31099, -29247, -27010, -24495, -21789, -18953, -16059, -13161, -10298, -7535, -4905, -2445, -205, 1792, 3521, 4948, 6061, 6843, 7282, 7381, 7126, 6681, 6239, 5802, 5373, 4947, 4528, 4116, 3708, 3313, 2903, 2621, 3019, 3915, 5113, 6538, 8137, 9866, 11675, 13530, 15402, 17251, 19050, 20774, 22388, 23876, 25215, 26380, 27357, 28132, 28688, 29018, 29110, 28966, 28574, 27947, 27044, 25554, 23646, 21522, 19224, 16804, 14303, 11740, 9152, 6565, 3990, 1460, -1004, -3395, -5682, -7854, -9899, -11796, -13535, -15108, -16499, -17703, -18711, -19516, -20117, -20508, -20688, -20660, -20423, -19979, -19442, -18904, -18365, -17823, -17278, -16732, -16198, -15293, -13878, -12189, -10299, -8257, -6094, -3850, -1555, 773, 3102, 5410, 7681, 9887, 12013, 14047, 15961, 17747, 19394, 20882, 22208, 23361, 24329, 25113, 25703, 26100, 25672, 29128, 11670, -16908, -12578, -12575, -11903, -11237, -10579, -9931, -9336, -8446, -10727, -19437, -7829, 5643, -4757, -5062, -4273, -3763, -3205, -2656, -2119, -1599, -1069, -632, -1677, -4106, -7202, -10718, -14412, -18060, -21493, -24533, -27024, -28861, -29941, -30202, -29602, -28057, -25961, -23601, -21050, -18367, -15584, -12748, -9890, -7033, -4217, -1405};