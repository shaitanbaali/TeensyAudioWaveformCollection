/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0818 256 samples */
 
const int16_t AKWF_0818_256_DATA [256] = 
{5474, 13039, 19823, 25369, 28875, 30133, 29463, 27381, 22858, 16352, 9792, 3421, -2461, -7319, -10892, -13210, -14481, -14959, -14853, -14334, -13530, -12540, -11441, -10284, -9117, -7970, -6859, -5806, -4815, -3893, -3043, -2265, -1556, -917, -343, 167, 617, 1010, 1351, 1641, 1890, 2094, 2252, 4104, 7518, 10666, 13505, 15862, 17265, 17485, 16575, 15071, 11213, 2747, -6343, -14728, -22347, -28283, -31784, -32762, -31718, -28962, -23186, -15781, -8470, -1429, 4916, 10011, 13610, 15836, 16952, 17227, 16898, 16142, 15100, 13873, 12542, 11173, 9800, 8462, 7181, 5968, 4833, 3784, 2819, 1939, 1146, 432, -204, -763, -1254, -1680, -2043, -2349, -2600, -2802, -2958, -3072, -3148, -3190, -3201, -3184, -3141, -3076, -2993, -2892, -2777, -2650, -2513, -2370, -2221, -2067, -1910, -1753, -1596, -1441, -1286, -1137, -991, -851, -716, -588, -465, -350, -242, -141, -47, 39, 118, 190, 254, 311, 362, 406, 445, 477, 502, 522, 536, 546, 551, 552, 549, 542, 533, 521, 506, 490, 472, 452, 431, 409, 386, 362, 338, 312, 288, 263, 239, 216, 192, 170, 149, 128, 108, 90, 73, 57, 41, 27, 13, 0, -11, -21, -30, -39, -45, -51, -57, -62, -65, -66, -67, -70, -70, -71, -72, -71, -70, -69, -67, -65, -62, -59, -57, -54, -51, -47, -43, -40, -36, -33, -29, -27, -24, -21, -19, -16, -13, -10, -9, -6, -4, -1, 1, 2, 3, 4, 4, 6, 7, 6, 7, 8, 8, 9, 9, 8, 9, 10, 9, 9, 10, 9, 8, 8, 8, 7, 7, 6, 6, 5, 3, -14, 56, -952, -3726, -6534, -9053, -11247, -12724, -13195, -12658, -11497, -9056, -2328};