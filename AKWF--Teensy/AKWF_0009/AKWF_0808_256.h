/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0808 256 samples */
 
const int16_t AKWF_0808_256_DATA [256] = 
{319, 891, 1520, 2205, 2929, 3689, 4468, 5274, 6328, 7645, 8900, 9950, 10844, 11661, 12443, 13167, 13783, 14245, 14532, 14650, 14620, 14473, 14236, 13925, 13558, 13144, 12710, 12140, 13046, 17443, 21952, 23560, 22761, 20893, 18782, 16632, 14292, 11544, 8321, 4744, 1003, -2686, -6137, -9246, -11952, -14226, -16085, -17538, -18606, -19324, -19719, -19823, -19673, -19298, -18736, -18005, -16834, -15019, -12814, -10504, -8228, -6038, -4009, -2215, -718, 434, 1241, 1725, 1927, 1892, 1670, 1302, 820, 256, -362, -1013, -1677, -2333, -2969, -3573, -4130, -4638, -5087, -5469, -5782, -6057, -5549, -4286, -3364, -2715, -2460, -2654, -3061, -3563, -4091, -4604, -5064, -5434, -5683, -5789, -5745, -5547, -5201, -4718, -4112, -3398, -2596, -1715, -773, 211, 1228, 2262, 3297, 4327, 5340, 6325, 7276, 8183, 9038, 9837, 10577, 11246, 11861, 12731, 13925, 15130, 16152, 16892, 17302, 17372, 17116, 16565, 15758, 14734, 13533, 12203, 10774, 9280, 7758, 6228, 4719, 3233, 1944, 1247, 1005, 992, 1079, 1175, 1223, 1190, 1061, 830, 497, 70, -445, -1035, -1688, -2392, -3152, -3879, -5086, -8960, -14746, -20312, -24893, -28376, -30826, -32287, -32788, -32365, -31097, -29108, -26453, -22798, -18382, -13743, -9197, -4920, -1041, 2376, 5330, 7812, 9844, 11464, 12702, 13595, 14185, 14509, 14599, 14489, 14211, 13791, 13253, 12626, 11904, 11293, 11276, 11708, 12294, 12867, 13320, 13590, 13644, 13471, 13072, 12465, 11664, 10693, 9579, 8340, 7002, 5593, 4125, 2623, 1110, -403, -1900, -3364, -4790, -6158, -7461, -8699, -9834, -11028, -12712, -14642, -16478, -18040, -19223, -19990, -20337, -20287, -19876, -19152, -18163, -16955, -15574, -14068, -12469, -10817, -9146, -7473, -5830, -4233, -2715, -1679, -1221, -1081, -1097, -1162, -1204, -1183, -1074, -868, -566, -155};