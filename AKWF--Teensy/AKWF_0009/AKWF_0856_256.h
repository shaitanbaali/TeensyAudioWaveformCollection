/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0856 256 samples */
 
const int16_t AKWF_0856_256_DATA [256] = 
{310, 885, 1543, 2189, 2833, 3522, 4257, 5035, 5852, 6697, 7550, 8398, 9227, 10037, 10837, 11648, 12477, 13346, 14243, 15160, 16111, 17032, 18474, 19859, 20073, 20596, 20973, 21158, 21359, 21619, 21966, 22508, 23215, 23980, 24716, 25467, 26293, 27182, 28060, 28822, 29335, 29545, 29638, 29868, 30324, 30885, 31387, 31760, 32028, 32238, 32419, 32570, 32679, 32745, 32767, 32746, 32679, 32570, 32421, 32232, 32004, 31742, 31444, 31115, 30755, 30370, 29956, 29517, 29062, 28579, 28081, 27568, 27038, 26493, 25935, 25365, 24786, 24195, 23593, 22983, 22366, 21742, 21108, 20466, 19821, 19139, 18749, 18052, 16388, 15521, 14632, 13628, 12644, 11665, 10703, 9828, 9015, 8201, 7325, 6459, 5707, 5118, 4672, 4277, 3729, 2909, 1948, 1085, 439, -46, -506, -1004, -1529, -2058, -2575, -3081, -3582, -4101, -4662, -5249, -6349, -7882, -8492, -8954, -9347, -9742, -10206, -10649, -11077, -11517, -11964, -12425, -12882, -13343, -13797, -14241, -14670, -15089, -15497, -15910, -16337, -16769, -17207, -17630, -18022, -18367, -18647, -18849, -18946, -18967, -18349, -17696, -18147, -18257, -18497, -18941, -19405, -19867, -20297, -20581, -20736, -20839, -20953, -21008, -20917, -20689, -20390, -20134, -20060, -20237, -20482, -20552, -20358, -20024, -19715, -19497, -19343, -19207, -19062, -18903, -18747, -18594, -18447, -18306, -18173, -18045, -17921, -17804, -17695, -17587, -17482, -17381, -17280, -17184, -17086, -16988, -16885, -16784, -16680, -16573, -16464, -16349, -16232, -16113, -15991, -15865, -15736, -15606, -15472, -15335, -15197, -15061, -14917, -14804, -14395, -14282, -15133, -15180, -15246, -15421, -15570, -15714, -15833, -15863, -15824, -15787, -15804, -15809, -15692, -15414, -14983, -14497, -14157, -14082, -14138, -14090, -13807, -13358, -12860, -12379, -11910, -11407, -10846, -10218, -9485, -8682, -7185, -5553, -4722, -3953, -3252, -2593, -1966, -1359, -774, -213};