/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0899 256 samples */
 
const int16_t AKWF_0899_256_DATA [256] = 
{813, 2080, 3162, 4091, 4861, 5470, 5912, 6196, 6326, 6308, 6149, 5865, 5461, 4956, 4363, 3693, 2968, 2196, 1401, 595, -220, -1016, -1785, -2518, -3209, -3843, -4419, -4933, -5379, -5756, -6061, -6301, -6473, -6577, -6627, -6621, -6561, -6458, -6320, -6146, -5943, -5723, -5490, -5241, -4990, -4744, -4495, -4249, -4018, -3795, -3582, -3382, -3195, -3018, -2851, -2695, -2545, -2401, -2262, -2127, -1987, -1847, -1702, -1552, -1393, -1226, -1049, -860, -661, -449, -226, 6, 249, 498, 760, 1028, 1298, 1571, 1846, 2121, 2391, 2657, 2917, 3167, 3406, 3636, 3848, 4047, 4233, 4400, 4550, 4680, 4796, 4891, 4966, 5027, 5070, 5093, 5105, 5101, 5083, 5051, 5013, 4963, 4904, 4842, 4775, 4702, 4630, 4559, 4489, 4422, 4361, 4307, 4258, 4221, 4194, 4175, 4170, 4180, 4201, 4236, 4288, 4353, 4431, 4528, 4636, 4759, 4897, 5050, 5215, 5388, 5576, 5775, 5980, 6194, 6418, 6644, 6872, 7110, 7344, 7575, 7815, 8049, 8275, 8499, 8721, 8933, 9134, 9335, 9522, 9696, 9866, 10025, 10167, 10299, 10427, 10540, 10637, 10731, 10816, 10884, 10946, 11005, 11052, 11088, 11128, 11160, 11182, 11204, 11228, 11246, 11260, 11286, 11304, 11322, 11353, 11382, 11408, 11448, 11492, 11536, 11587, 11650, 11715, 11780, 11862, 11947, 12032, 12129, 12234, 12339, 12447, 12568, 12690, 12809, 12942, 13078, 13210, 13342, 13480, 13654, 13283, 12226, 11003, 9591, 8135, 6556, 4652, 2470, 93, -2382, -4872, -7299, -9616, -11829, -13952, -15982, -17923, -19795, -21549, -23205, -24751, -26179, -27480, -28638, -29701, -30626, -31380, -32005, -32453, -32699, -32767, -32664, -32387, -31888, -31248, -30439, -29448, -28313, -27037, -25606, -24047, -22393, -20633, -18789, -16896, -14968, -13024, -11056, -9128, -7244, -5428, -3695, -2066, -533};