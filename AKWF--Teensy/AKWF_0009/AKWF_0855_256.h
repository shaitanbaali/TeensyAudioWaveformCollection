/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0855 256 samples */
 
const int16_t AKWF_0855_256_DATA [256] = 
{1696, 4542, 7210, 9745, 12118, 14310, 16304, 18076, 19619, 20919, 21961, 22742, 23249, 23501, 23264, 22493, 21465, 20245, 18881, 17415, 15872, 14286, 12686, 11093, 9535, 8036, 6614, 5292, 4088, 3016, 2094, 1333, 743, 332, 106, 55, 58, 55, 53, 52, 52, 51, 49, 49, 49, 48, 48, 47, 45, 46, 45, 44, 45, 45, 44, 43, 42, 43, 43, 42, 43, 42, 41, 42, 42, 42, 42, 42, 42, 42, 42, 42, 42, 42, 42, 42, 42, 42, 41, 42, 41, 41, 40, 41, 41, 42, 44, 35, 394, 1219, 2288, 3545, 4950, 6478, 8096, 9782, 11524, 13290, 15067, 16839, 18583, 20285, 21934, 23505, 24993, 26381, 27655, 28808, 29829, 30707, 31437, 32014, 32426, 32680, 32753, 32036, 30584, 28748, 26605, 24212, 21625, 18889, 16029, 13091, 10106, 7096, 4103, 1151, -1740, -4533, -7208, -9749, -12121, -14313, -16307, -18080, -19622, -20923, -21965, -22745, -23253, -23505, -23268, -22496, -21469, -20248, -18884, -17418, -15875, -14288, -12689, -11095, -9536, -8038, -6614, -5292, -4089, -3016, -2095, -1334, -743, -332, -106, -55, -57, -54, -53, -52, -51, -50, -49, -49, -49, -47, -46, -46, -45, -46, -44, -43, -44, -44, -43, -42, -43, -42, -42, -42, -43, -42, -41, -42, -41, -41, -41, -41, -41, -41, -41, -41, -41, -41, -41, -41, -41, -41, -41, -42, -41, -39, -40, -39, -39, -41, -43, -34, -393, -1219, -2288, -3545, -4950, -6477, -8095, -9783, -11524, -13290, -15068, -16840, -18583, -20286, -21934, -23505, -24993, -26381, -27655, -28809, -29830, -30707, -31438, -32014, -32427, -32682, -32754, -32037, -30585, -28749, -26606, -24213, -21627, -18891, -16031, -13093, -10108, -7104, -4118, -1115};