/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0853 256 samples */
 
const int16_t AKWF_0853_256_DATA [256] = 
{663, 1633, 2534, 3397, 4222, 5014, 5777, 6509, 7216, 7901, 8560, 9201, 9822, 10424, 11010, 11579, 12133, 12673, 13199, 13710, 14210, 14698, 15173, 15639, 16093, 16536, 16971, 17396, 17811, 18218, 18615, 19004, 19386, 19759, 20124, 20483, 20833, 21177, 21514, 21843, 22166, 22483, 22793, 23098, 23396, 23688, 23974, 24254, 24528, 24798, 25061, 25319, 25572, 25820, 26061, 26299, 26532, 26759, 26981, 27199, 27411, 27620, 27823, 28021, 28216, 28405, 28590, 28771, 28947, 29119, 29286, 29450, 29609, 29764, 29914, 30061, 30203, 30341, 30476, 30606, 30732, 30855, 30973, 31087, 31198, 31305, 31407, 31506, 31601, 31692, 31779, 31863, 31943, 32019, 32092, 32160, 32225, 32286, 32344, 32397, 32447, 32494, 32537, 32576, 32610, 32643, 32671, 32696, 32717, 32735, 32749, 32759, 32765, 32768, 32565, 33596, 27402, 17531, 14727, 12037, 9919, 8111, 6507, 5065, 3748, 2527, 1392, 328, -677, -1627, -2532, -3396, -4221, -5013, -5776, -6508, -7215, -7900, -8560, -9200, -9822, -10423, -11009, -11579, -12131, -12672, -13198, -13709, -14209, -14697, -15172, -15637, -16092, -16535, -16970, -17395, -17810, -18216, -18614, -19003, -19385, -19758, -20123, -20482, -20832, -21175, -21512, -21842, -22165, -22483, -22792, -23097, -23395, -23686, -23973, -24253, -24526, -24796, -25060, -25318, -25570, -25817, -26060, -26298, -26530, -26757, -26979, -27197, -27409, -27618, -27821, -28020, -28214, -28403, -28588, -28769, -28945, -29117, -29285, -29448, -29607, -29762, -29913, -30060, -30202, -30340, -30475, -30605, -30731, -30854, -30972, -31086, -31197, -31303, -31406, -31504, -31599, -31691, -31778, -31862, -31941, -32017, -32090, -32158, -32223, -32285, -32341, -32395, -32446, -32492, -32536, -32574, -32609, -32642, -32670, -32694, -32715, -32733, -32746, -32757, -32764, -32767, -32563, -33594, -27401, -17530, -14726, -12036, -9919, -8109, -6506, -5064, -3747, -2528, -1396, -315};