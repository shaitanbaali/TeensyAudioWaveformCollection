/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0859 256 samples */
 
const int16_t AKWF_0859_256_DATA [256] = 
{562, 1721, 2776, 3755, 4660, 5490, 6246, 6927, 7537, 8076, 8543, 8940, 9264, 9514, 9678, 9707, 9745, 9848, 9959, 10069, 10174, 10268, 10348, 10413, 10462, 10495, 10511, 10511, 10475, 10423, 10523, 3969, -4379, -5648, -5070, -4331, -3585, -2888, -2254, -1685, -1181, -743, -375, -80, 91, 230, 448, 685, 927, 1169, 1405, 1630, 1846, 2049, 2238, 2414, 2577, 2724, 2857, 2978, 3085, 3178, 3259, 3328, 3385, 3431, 3467, 3494, 3510, 3518, 3518, 3449, 3675, 2377, -7237, -12474, -12454, -11793, -11018, -10265, -9566, -8929, -8364, -7914, -7487, -6987, -6472, -5952, -5435, -4926, -4424, -3938, -3462, -3002, -2558, -2129, -1714, -1316, -934, -567, -216, 120, 442, 749, 1043, 1322, 1589, 1843, 2085, 2316, 2535, 2742, 2939, 3124, 3200, 3885, -26, -9712, -12116, -11555, -10651, -9698, -8782, -7923, -7131, -6403, -5782, -5218, -4590, -3948, -3307, -2671, -2049, -1441, -847, -275, 280, 818, 1333, 1830, 2308, 2763, 3200, 3618, 4016, 4396, 4757, 5098, 5423, 5732, 6022, 6297, 6555, 6798, 7027, 7241, 7421, 7583, 7960, 982, -6884, -7641, -6893, -5946, -4991, -4082, -3230, -2440, -1712, -1046, -465, 17, 532, 1076, 1621, 2159, 2683, 3193, 3686, 4159, 4614, 5050, 5462, 5857, 6232, 6584, 6918, 7232, 7526, 7803, 8060, 8298, 8521, 8726, 8915, 9087, 9244, 9387, 9515, 9568, 9901, 8752, -297, -5714, -5652, -4862, -3962, -3075, -2242, -1461, -737, -69, 542, 1094, 1583, 1971, 2335, 2749, 3169, 3585, 3781, 5182, 1173, -29227, -31647, -28426, -26489, -24353, -22261, -20210, -18207, -16266, -14382, -12562, -10814, -9134, -7525, -5994, -4534, -3150, -1845, -614, 432, 2046, -1045, -11835, -14270, -12848, -11216, -9514, -7852, -6259, -4740, -3295, -1929, -618};