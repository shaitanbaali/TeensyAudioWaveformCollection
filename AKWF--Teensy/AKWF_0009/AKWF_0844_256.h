/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0844 256 samples */
 
const int16_t AKWF_0844_256_DATA [256] = 
{5407, 12688, 18562, 22900, 25502, 25996, 24257, 21622, 18538, 15176, 11710, 8261, 4954, 1912, -784, -3046, -4798, -5993, -6611, -6470, -5709, -4742, -3670, -2567, -1506, -544, 270, 894, 1297, 1456, 1287, 927, 493, 18, -473, -959, -1415, -1826, -2176, -2450, -2639, -2740, -2721, -2595, -2428, -2236, -2024, -1800, -1571, -1339, -1111, -892, -684, -492, -320, -170, -44, 55, 126, 167, 177, 159, 130, 95, 56, 16, -26, -70, -112, -152, -190, -224, -256, -283, -304, -321, -331, -336, -335, -325, -315, -303, -288, -273, -257, -240, -222, -204, -185, -167, -147, -128, -109, -89, -70, -51, -33, -16, 1, 17, 34, 49, 63, 77, 90, 101, 112, 121, 130, 138, 144, 148, 152, 154, 158, 133, 49, -63, -195, -345, -508, -686, -874, -1073, -1282, -1500, -1725, -1959, -2201, -2449, -2704, -2966, -3233, -3507, -3786, -4069, -4358, -4651, -4948, -5250, -5556, -5865, -6179, -6496, -6816, -7138, -7464, -7793, -8124, -8457, -8793, -9131, -9470, -9811, -10153, -10498, -10843, -11189, -11537, -11885, -12234, -12584, -12934, -13285, -13635, -13985, -14335, -14685, -15035, -15385, -15733, -16080, -16428, -16774, -17119, -17462, -17804, -18145, -18485, -18821, -19157, -19491, -19821, -20152, -20479, -20804, -21126, -21446, -21762, -22077, -22388, -22696, -23002, -23304, -23602, -23898, -24190, -24478, -24762, -25043, -25321, -25594, -25862, -26128, -26389, -26644, -26897, -27145, -27388, -27626, -27861, -28089, -28314, -28534, -28748, -28959, -29163, -29362, -29557, -29746, -29930, -30108, -30282, -30448, -30612, -30768, -30918, -31064, -31203, -31338, -31466, -31587, -31704, -31815, -31919, -32018, -32111, -32197, -32277, -32352, -32420, -32483, -32538, -32589, -32632, -32671, -32703, -32728, -32747, -32714, -32894, -31583, -26144, -18850, -10767, -2332};