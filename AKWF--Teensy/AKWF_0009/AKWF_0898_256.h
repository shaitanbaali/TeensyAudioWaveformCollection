/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0898 256 samples */
 
const int16_t AKWF_0898_256_DATA [256] = 
{1150, 3974, 6782, 9636, 12499, 15351, 18128, 20760, 23173, 25275, 26989, 28287, 29153, 29617, 29738, 29595, 29274, 28859, 28435, 28049, 27719, 27406, 27105, 26794, 26404, 25922, 25309, 24570, 23689, 22700, 21656, 20611, 19633, 18764, 18015, 17334, 16693, 16041, 15275, 14301, 13010, 11353, 9321, 6931, 4231, 1299, -1767, -4867, -7887, -10762, -13432, -15879, -18116, -20162, -22050, -23809, -25455, -26993, -28423, -29716, -30839, -31756, -32408, -32737, -32716, -32332, -31607, -30569, -29272, -27793, -26192, -24532, -22859, -21217, -19615, -18026, -16425, -14760, -12993, -11108, -9125, -7024, -4841, -2614, -379, 1812, 3935, 5953, 7833, 9544, 11095, 12479, 13716, 14836, 15861, 16822, 17759, 18682, 19584, 20455, 21268, 21997, 22605, 23064, 23343, 23414, 23243, 22812, 22172, 21304, 20236, 18987, 17609, 16130, 14606, 13110, 11679, 10355, 9139, 8012, 6918, 5815, 4694, 3544, 2365, 1159, -53, -1239, -2380, -3439, -4413, -5291, -6072, -6785, -7455, -8125, -8863, -9746, -10830, -12160, -13710, -15415, -17196, -18960, -20609, -22068, -23268, -24159, -24711, -24931, -24848, -24513, -23973, -23265, -22433, -21505, -20471, -19314, -18017, -16540, -14826, -12858, -10591, -8016, -5194, -2224, 761, 3614, 6206, 8456, 10307, 11781, 12906, 13744, 14382, 14908, 15408, 15937, 16524, 17171, 17857, 18556, 19226, 19805, 20244, 20512, 20607, 20546, 20375, 20146, 19906, 19697, 19521, 19437, 19420, 19439, 19459, 19422, 19271, 18938, 18398, 17630, 16657, 15507, 14211, 12788, 11225, 9582, 7905, 6220, 4550, 2888, 1221, -468, -2188, -3982, -5858, -7816, -9868, -11968, -14082, -16169, -18184, -20081, -21836, -23401, -24751, -25878, -26776, -27474, -28006, -28409, -28727, -28973, -29161, -29297, -29381, -29414, -29377, -29262, -29052, -28694, -28147, -27366, -26329, -25017, -23448, -21621, -19543, -17251, -14787, -12232, -9603, -6943, -4262, -1510};