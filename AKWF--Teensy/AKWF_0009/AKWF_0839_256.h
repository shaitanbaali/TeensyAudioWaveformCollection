/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0839 256 samples */
 
const int16_t AKWF_0839_256_DATA [256] = 
{32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 31948, 36427, 14263, -24866, -20228, -21116, -21150, -21168, -21187, -21206, -21227, -21245, -21264, -21285, -21304, -21323, -21343, -21362, -21381, -21401, -21420, -21439, -21459, -21479, -21497, -21516, -21537, -21555, -21570, -21616, -21522, -21139, -21156, -21154, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21153, -21009, -21795, -18587, -134, 72, -41, 0, 0, 0, 0, 0, 0, 0, 0};