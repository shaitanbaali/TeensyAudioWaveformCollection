/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0863 256 samples */
 
const int16_t AKWF_0863_256_DATA [256] = 
{31650, 28941, 26366, 23860, 21438, 19098, 16843, 14684, 12615, 10639, 8765, 6986, 5306, 3733, 2258, 886, -380, -1544, -2605, -3560, -4415, -5166, -5816, -6367, -6818, -7172, -7432, -7597, -7672, -7656, -7555, -7370, -7104, -6761, -6342, -5851, -5292, -4668, -3982, -3240, -2441, -1594, -701, 237, 1214, 2223, 3266, 4334, 5425, 6536, 7663, 8799, 9945, 11093, 12240, 13385, 14521, 15647, 16761, 17854, 18926, 19751, 21898, 18735, -28660, -30044, -26366, -24091, -21673, -19337, -17084, -14927, -12860, -10884, -9010, -7230, -5549, -3972, -2496, -1120, 150, 1319, 2384, 3345, 4206, 4964, 5621, 6179, 6638, 7000, 7267, 7441, 7524, 7517, 7425, 7250, 6994, 6660, 6250, 5769, 5220, 4605, 3929, 3197, 2409, 1570, 687, -239, -1208, -2207, -3241, -4299, -5380, -6483, -7600, -8728, -9864, -11004, -12142, -13280, -14409, -15525, -16631, -17717, -18781, -19599, -21738, -18570, 28833, 30223, 26552, 24282, 21870, 19540, 17293, 15143, 13080, 11109, 9241, 7466, 5790, 4219, 2746, 1375, 111, -1053, -2115, -3070, -3926, -4680, -5333, -5887, -6341, -6699, -6962, -7132, -7210, -7199, -7103, -6923, -6662, -6323, -5911, -5424, -4870, -4251, -3571, -2833, -2040, -1197, -308, 624, 1597, 2602, 3639, 4705, 5791, 6899, 8023, 9155, 10297, 11443, 12587, 13729, 14865, 15988, 17099, 18191, 18606, 23290, 7333, -34208, -28889, -26704, -24219, -21762, -19395, -17109, -14909, -12805, -10791, -8870, -7052, -5329, -3705, -2186, -766, 551, 1762, 2872, 3880, 4782, 5584, 6283, 6882, 7381, 7783, 8088, 8298, 8416, 8443, 8383, 8236, 8007, 7697, 7310, 6851, 6319, 5721, 5059, 4335, 3558, 2725, 1843, 917, -52, -1059, -2097, -3168, -4264, -5379, -6516, -7666, -8824, -9990, -11159, -12325, -13487, -14642, -15782, -16908, -18017, -19099, -20159, -21189, -22207};