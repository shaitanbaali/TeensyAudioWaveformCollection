/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0817 256 samples */
 
const int16_t AKWF_0817_256_DATA [256] = 
{177, 442, 681, 898, 1093, 1269, 1441, 1665, 1258, 9816, 27060, 31428, 28316, 25012, 18261, 8235, -2095, -10507, -16267, -19607, -21093, -21230, -20427, -18983, -17124, -15027, -12813, -10591, -8433, -6379, -4468, -2720, -1137, 268, 1506, 2581, 3499, 4272, 4907, 5413, 5804, 6088, 6279, 6385, 6413, 6374, 6276, 6126, 5931, 5698, 5434, 5146, 4838, 4512, 4176, 3831, 3483, 3137, 2793, 2456, 2126, 1805, 1499, 1204, 922, 656, 409, 176, -40, -251, -396, -837, -2620, -4805, -6753, -8521, -9881, -10572, -10542, -9901, -8832, -7493, -6017, -4506, -3017, -1601, -294, 889, 1937, 2851, 3652, 4328, 4878, 5316, 5640, 5855, 5973, 6000, 5948, 5826, 5645, 5415, 5141, 4833, 4501, 4145, 3778, 3402, 3023, 2645, 2271, 1903, 1546, 1200, 870, 556, 257, -21, -279, -519, -740, -939, -1116, -1275, -1413, -1534, -1635, -1718, -1785, -1836, -1869, -1891, -1900, -1894, -1990, -1609, -3137, -22809, -33238, -29684, -27020, -21723, -12106, -1010, 8611, 15565, 19868, 22040, 22663, 22183, 20947, 19199, 17140, 14919, 12640, 10395, 8241, 6212, 4339, 2630, 1091, -273, -1472, -2513, -3400, -4146, -4760, -5250, -5631, -5911, -6096, -6199, -6231, -6194, -6102, -5959, -5774, -5551, -5298, -5021, -4723, -4410, -4087, -3755, -3420, -3087, -2757, -2431, -2112, -1800, -1502, -1216, -941, -682, -440, -213, -4, 189, 367, 526, 672, 802, 916, 1015, 1099, 1169, 1226, 1272, 1316, 1285, 2012, 4024, 6065, 7888, 9466, 10519, 10837, 10436, 9470, 8128, 6576, 4930, 3286, 1705, 225, -1119, -2316, -3359, -4241, -4972, -5558, -6005, -6327, -6533, -6634, -6641, -6569, -6425, -6222, -5967, -5668, -5336, -4977, -4596, -4201, -3796, -3389, -2980, -2574, -2178, -1793, -1421, -1063, -723, -403, -96};