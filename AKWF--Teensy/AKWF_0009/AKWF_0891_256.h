/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0891 256 samples */
 
const int16_t AKWF_0891_256_DATA [256] = 
{703, 1644, 2415, 3038, 3508, 3821, 4041, 3781, 5220, 8450, 9758, 11620, 14003, 16836, 20086, 23659, 27715, 31464, 29011, 29613, 30816, 30899, 30209, 28888, 27081, 24957, 22197, 21937, 22059, 20653, 19851, 19421, 19283, 19335, 19484, 19649, 19761, 19769, 19624, 19297, 18770, 18035, 17093, 15952, 14635, 13165, 11571, 9886, 8150, 6393, 4654, 2974, 1376, -106, -1443, -2624, -3626, -4439, -5058, -5485, -5720, -5775, -5660, -5391, -4990, -4477, -3871, -3200, -2487, -1752, -1019, -311, 356, 967, 1505, 1965, 2333, 2606, 2785, 2864, 2856, 2760, 2582, 2337, 2033, 1682, 1295, 887, 466, 50, -355, -737, -1089, -1402, -1670, -1888, -2054, -2169, -2229, -2236, -2196, -2114, -1992, -1836, -1652, -1447, -1231, -1006, -780, -559, -351, -158, 14, 163, 286, 381, 447, 484, 495, 478, 437, 373, 292, 193, 86, -30, -153, -275, -395, -510, -616, -710, -793, -863, -917, -955, -980, -987, -979, -959, -926, -884, -832, -775, -712, -645, -578, -511, -449, -391, -337, -290, -250, -220, -196, -182, -177, -178, -188, -204, -226, -252, -282, -317, -352, -388, -423, -458, -489, -519, -543, -566, -584, -596, -606, -608, -608, -603, -593, -583, -568, -552, -533, -514, -494, -474, -455, -437, -419, -406, -393, -384, -376, -370, -366, -366, -370, -372, -378, -386, -393, -404, -413, -423, -434, -445, -454, -463, -499, -374, -964, -4141, -5775, -7607, -10005, -12870, -16128, -19715, -23549, -28015, -27217, -27139, -28861, -29417, -29209, -28351, -26973, -25225, -22857, -21772, -22197, -20820, -19795, -19098, -18655, -18383, -18211, -18071, -17907, -17676, -17342, -16883, -16278, -15529, -14630, -13591, -12432, -11164, -9815, -8411, -6976, -5544, -4138, -2786, -1515, -325};