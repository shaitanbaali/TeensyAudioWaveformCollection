/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0834 256 samples */
 
const int16_t AKWF_0834_256_DATA [256] = 
{309, 1331, 2349, 3383, 4425, 5474, 6530, 7585, 8640, 9693, 10739, 11779, 12811, 13828, 14833, 15824, 16795, 17751, 18687, 19599, 20490, 21356, 22196, 23011, 23798, 24555, 25284, 25981, 26647, 27282, 27882, 28449, 28982, 29480, 29941, 30367, 30756, 31107, 31421, 31697, 31934, 32133, 32292, 32410, 32490, 32529, 32527, 32485, 32403, 32278, 32113, 31907, 31660, 31370, 31041, 30670, 30256, 29803, 29309, 28773, 28198, 27581, 26926, 26232, 25496, 24726, 23916, 23070, 22192, 21281, 20340, 19374, 18382, 17363, 16327, 15269, 14192, 13102, 11997, 10878, 9753, 8616, 7473, 6328, 5176, 4023, 2873, 1720, 573, -568, -1706, -2836, -3956, -5069, -6169, -7256, -8333, -9393, -10437, -11469, -12480, -13474, -14449, -15404, -16339, -17254, -18145, -19015, -19863, -20686, -21487, -22262, -23012, -23738, -24438, -25111, -25759, -26379, -26972, -27539, -28078, -28587, -29071, -29525, -29949, -30346, -30714, -31052, -31361, -31638, -31887, -32105, -32292, -32449, -32575, -32670, -32733, -32764, -32764, -32730, -32665, -32567, -32437, -32273, -32076, -31845, -31581, -31284, -30951, -30585, -30185, -29750, -29280, -28777, -28238, -27664, -27057, -26413, -25736, -25025, -24276, -23496, -22681, -21831, -20949, -20033, -19083, -18101, -17080, -16056, -14486, -12063, -9399, -6684, -3982, -1348, 1174, 3577, 5839, 7943, 9892, 11672, 13276, 14709, 15966, 17044, 17951, 18681, 19241, 19635, 19865, 19938, 19861, 19638, 19277, 18785, 18177, 17462, 16652, 15765, 14807, 13790, 12727, 11624, 10490, 9338, 8169, 6993, 5822, 4654, 3497, 2360, 1241, 149, -910, -1940, -2931, -3882, -4792, -5657, -6474, -7245, -7964, -8629, -9244, -9802, -10304, -10751, -11139, -11470, -11743, -11955, -12110, -12205, -12240, -12217, -12134, -11994, -11795, -11538, -11226, -10857, -10433, -9956, -9425, -8842, -8211, -7530, -6803, -6032, -5219, -4370, -3487, -2574, -1635, -652};