/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0811 256 samples */
 
const int16_t AKWF_0811_256_DATA [256] = 
{1975, 4964, 7777, 10452, 12957, 15270, 17367, 19223, 20840, 22221, 23367, 24294, 25020, 25560, 25938, 26183, 26316, 26364, 26347, 26274, 26165, 26031, 25877, 25701, 25501, 25272, 25003, 24682, 24307, 23863, 23341, 22738, 22046, 21266, 20400, 19454, 18440, 17364, 16240, 15091, 13923, 12759, 11615, 10497, 9427, 8413, 7456, 6565, 5740, 4975, 4272, 3627, 3025, 2460, 1926, 1412, 909, 411, -82, -580, -1085, -1590, -2095, -2598, -3089, -3563, -4012, -4430, -4809, -5140, -5422, -5655, -5831, -5952, -6020, -6041, -6019, -5957, -5863, -5744, -5610, -5467, -5320, -5175, -5030, -4898, -4779, -4667, -4567, -4473, -4382, -4296, -4201, -4106, -3993, -3867, -3748, -3206, -1538, 1320, 4964, 9178, 13645, 17865, 21550, 24624, 27157, 29265, 30921, 32046, 32638, 32768, 32551, 32047, 31251, 30147, 28735, 27066, 25191, 23115, 20843, 18370, 15709, 12913, 10022, 7051, 4035, 1003, -2008, -4942, -7763, -10444, -12950, -15263, -17361, -19217, -20836, -22217, -23363, -24292, -25018, -25558, -25938, -26182, -26317, -26365, -26345, -26275, -26166, -26033, -25880, -25703, -25502, -25274, -25003, -24684, -24309, -23865, -23344, -22740, -22048, -21269, -20404, -19457, -18443, -17367, -16244, -15094, -13929, -12764, -11619, -10502, -9431, -8417, -7460, -6567, -5743, -4979, -4276, -3629, -3027, -2463, -1929, -1414, -911, -414, 80, 577, 1082, 1588, 2093, 2597, 3088, 3561, 4010, 4428, 4807, 5138, 5420, 5653, 5830, 5951, 6019, 6040, 6018, 5957, 5862, 5743, 5610, 5467, 5320, 5174, 5030, 4898, 4779, 4667, 4566, 4471, 4379, 4294, 4200, 4105, 3993, 3866, 3746, 3207, 1547, -1308, -4951, -9164, -13631, -17852, -21538, -24614, -27148, -29259, -30916, -32042, -32637, -32768, -32552, -32049, -31254, -30151, -28740, -27072, -25198, -23123, -20851, -18380, -15718, -12923, -10033, -7067, -4060, -973};