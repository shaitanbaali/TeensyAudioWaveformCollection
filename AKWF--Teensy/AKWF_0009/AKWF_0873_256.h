/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0873 256 samples */
 
const int16_t AKWF_0873_256_DATA [256] = 
{663, 2390, 4120, 5882, 7663, 9454, 11249, 13031, 14797, 16537, 18238, 19896, 21499, 23034, 24498, 25877, 27158, 28333, 29387, 30298, 31039, 31614, 32055, 32380, 32601, 32728, 32769, 32732, 32623, 32446, 32205, 31905, 31553, 31157, 30723, 30248, 29738, 29186, 28590, 27948, 27248, 26483, 25647, 24727, 23716, 22612, 21404, 20093, 18684, 17173, 15571, 13891, 12136, 10324, 8474, 6592, 4703, 2823, 962, -854, -2614, -4307, -5912, -7418, -8821, -10102, -11257, -12281, -13165, -13907, -14509, -14964, -15276, -15449, -15485, -15388, -15165, -14826, -14376, -13825, -13185, -12465, -11677, -10837, -9952, -9038, -8111, -7178, -6259, -5366, -4508, -3701, -2957, -2286, -1701, -1210, -819, -539, -375, -330, -408, -610, -938, -1388, -1957, -2643, -3434, -4327, -5312, -6374, -7507, -8697, -9924, -11181, -12448, -13707, -14946, -16143, -17276, -18323, -19258, -20096, -20853, -21525, -22115, -22627, -23055, -23399, -23661, -23837, -23927, -23931, -23848, -23679, -23424, -23084, -22661, -22156, -21575, -20916, -20185, -19389, -18529, -17609, -16640, -15621, -14560, -13466, -12341, -11194, -10033, -8859, -7684, -6515, -5352, -4206, -3083, -1985, -923, 101, 1084, 2018, 2902, 3733, 4505, 5217, 5868, 6454, 6977, 7435, 7826, 8154, 8417, 8618, 8758, 8840, 8865, 8838, 8761, 8637, 8471, 8266, 8028, 7757, 7463, 7146, 6812, 6466, 6111, 5751, 5391, 5034, 4681, 4339, 4009, 3692, 3391, 3108, 2842, 2595, 2366, 2156, 1963, 1785, 1622, 1472, 1330, 1196, 1067, 937, 805, 668, 518, 353, 165, -62, -342, -683, -1091, -1573, -2132, -2771, -3487, -4276, -5129, -6031, -6972, -7934, -8898, -9849, -10770, -11640, -12448, -13180, -13820, -14363, -14798, -15119, -15320, -15400, -15355, -15183, -14887, -14465, -13920, -13254, -12473, -11575, -10568, -9461, -8251, -6950, -5566, -4102, -2572, -945};