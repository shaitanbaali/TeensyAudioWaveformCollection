/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0886 256 samples */
 
const int16_t AKWF_0886_256_DATA [256] = 
{409, 1925, 3442, 4980, 6524, 8065, 9596, 11100, 12577, 14023, 15424, 16783, 18096, 19352, 20558, 21710, 22802, 23839, 24819, 25739, 26605, 27416, 28170, 28872, 29521, 30118, 30667, 31166, 31616, 32012, 32337, 32579, 32726, 32768, 32696, 32505, 32191, 31748, 31175, 30473, 29639, 28675, 27587, 26374, 25038, 23590, 22025, 20352, 18581, 16707, 14742, 12704, 10604, 8470, 6320, 4159, 2010, -114, -2213, -4268, -6272, -8226, -10115, -11933, -13684, -15354, -16945, -18457, -19882, -21224, -22482, -23638, -24682, -25597, -26371, -26996, -27465, -27772, -27916, -27894, -27706, -27352, -26837, -26163, -25333, -24351, -23227, -21960, -20558, -19033, -17382, -15618, -13752, -11799, -9789, -7737, -5657, -3573, -1496, 568, 2596, 4586, 6534, 8422, 10252, 12019, 13713, 15340, 16894, 18370, 19773, 21103, 22352, 23533, 24638, 25669, 26633, 27527, 28351, 29112, 29807, 30437, 31001, 31479, 31859, 32132, 32289, 32319, 32221, 31987, 31616, 31106, 30459, 29673, 28751, 27698, 26514, 25202, 23772, 22222, 20561, 18800, 16938, 14989, 12970, 10889, 8772, 6642, 4506, 2393, 331, -1667, -3575, -5371, -7043, -8572, -9946, -11159, -12200, -13068, -13765, -14293, -14662, -14886, -14979, -14962, -14859, -14692, -14486, -14263, -14045, -13853, -13702, -13607, -13584, -13641, -13786, -14030, -14370, -14792, -15289, -15848, -16459, -17115, -17806, -18522, -19261, -20012, -20770, -21530, -22285, -23031, -23765, -24478, -25171, -25839, -26477, -27085, -27662, -28197, -28676, -29083, -29399, -29614, -29717, -29701, -29559, -29286, -28883, -28344, -27674, -26876, -25956, -24926, -23801, -22596, -21336, -20042, -18734, -17439, -16180, -14975, -13846, -12808, -11875, -11061, -10371, -9812, -9386, -9091, -8921, -8866, -8915, -9048, -9246, -9489, -9754, -10020, -10268, -10477, -10633, -10721, -10728, -10644, -10461, -10171, -9772, -9257, -8625, -7877, -7008, -6023, -4924, -3713, -2410, -999};