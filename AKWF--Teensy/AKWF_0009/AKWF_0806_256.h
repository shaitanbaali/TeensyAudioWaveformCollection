/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0806 256 samples */
 
const int16_t AKWF_0806_256_DATA [256] = 
{1756, 4912, 7244, 8956, 10135, 10874, 11246, 11319, 11146, 10777, 10255, 9611, 8879, 8087, 7252, 6392, 5528, 4668, 3826, 3011, 2227, 1484, 784, 129, -474, -1027, -1531, -1983, -2382, -2731, -3032, -3286, -3495, -3661, -3787, -3873, -3924, -3943, -3933, -3894, -3831, -3745, -3643, -3522, -3387, -3240, -3082, -2918, -2747, -2573, -2394, -2217, -2038, -1862, -1689, -1516, -1346, -1175, -993, -795, -570, -326, -80, 143, 323, 396, 282, 224, 409, 629, 789, 898, 948, 947, 910, 867, 831, 808, 798, 799, 806, 817, 830, 843, 852, 858, 859, 855, 845, 831, 811, 786, 756, 722, 685, 642, 598, 552, 504, 454, 404, 356, 306, 257, 211, 167, 123, 82, 44, 9, -23, -55, -81, -105, -128, -147, -165, -177, -190, -199, -206, -210, -213, -215, -212, -211, -207, -201, -195, -186, -180, -174, -175, -187, -227, -419, -232, -3621, -24932, -31336, -18494, -12422, -7661, -2968, 546, 3371, 5603, 7286, 8528, 9392, 9936, 10216, 10274, 10149, 9876, 9484, 8997, 8437, 7823, 7171, 6495, 5806, 5116, 4431, 3762, 3109, 2483, 1886, 1319, 789, 293, -164, -585, -966, -1310, -1618, -1887, -2119, -2319, -2486, -2619, -2725, -2802, -2851, -2876, -2880, -2861, -2825, -2770, -2699, -2615, -2507, -2496, -1472, -907, -2445, -2189, -1954, -1895, -1726, -1573, -1424, -1274, -1130, -989, -853, -722, -596, -477, -365, -258, -161, -70, 14, 90, 160, 223, 278, 327, 371, 406, 436, 462, 482, 496, 508, 514, 516, 513, 509, 500, 489, 476, 461, 445, 425, 405, 383, 362, 340, 317, 293, 271, 245, 220, 187, 138, 9, -122, -567, -14378, -29494, -22249, -12629, -7260, -2198};