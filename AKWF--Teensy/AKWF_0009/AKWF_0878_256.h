/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0878 256 samples */
 
const int16_t AKWF_0878_256_DATA [256] = 
{3120, 4803, 5757, 6521, 7145, 7673, 8128, 8523, 8867, 9169, 9419, 9708, 9994, 10250, 10643, 11127, 11732, 12426, 13156, 13884, 14582, 15217, 15776, 16266, 16701, 17098, 17472, 17831, 18184, 18538, 18893, 19253, 19619, 19989, 20365, 20747, 21133, 21523, 21916, 22311, 22709, 23108, 23507, 23908, 24309, 24707, 25105, 25501, 25894, 26286, 26675, 27059, 27440, 27817, 28189, 28557, 28919, 29276, 29628, 29974, 30314, 30649, 30979, 31304, 31627, 31948, 32278, 32655, 32781, 32764, 32767, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32763, 32781, 32675, 32313, 31993, 31682, 31374, 31063, 30751, 30435, 30114, 29789, 29461, 29128, 28790, 28450, 28106, 27756, 27405, 27051, 26693, 26334, 25971, 25606, 25239, 24871, 24501, 24130, 23757, 23384, 23010, 22638, 22246, 21805, 21329, 20733, 20111, 19500, 18849, 18125, 17370, 16651, 16008, 15389, 14761, 14129, 13503, 12708, 11814, 10669, 9278, 7577, 5151, -3032, -7298, -8720, -10178, -11380, -12456, -13446, -14378, -15267, -16120, -16949, -17757, -18544, -19318, -20079, -20825, -21563, -22291, -23011, -23724, -24429, -25128, -25822, -26514, -27202, -27890, -28579, -29275, -29983, -30709, -31473, -32393, -32803, -32758, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32762, -32784, -32678, -31889, -31156, -30511, -29890, -29287, -28696, -28115, -27537, -26966, -26399, -25832, -25268, -24706, -24142, -23581, -23020, -22457, -21896, -21334, -20770, -20206, -19641, -19074, -18506, -17935, -17362, -16788, -16209, -15626, -15040, -14447, -13848, -13244, -12628, -12002, -11364, -10708, -10031, -9329, -8590, -7802, -6944, -5969, -4842, -2894};