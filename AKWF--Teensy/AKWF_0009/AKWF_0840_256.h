/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0840 256 samples */
 
const int16_t AKWF_0840_256_DATA [256] = 
{1, 21, 75, 166, 304, 492, 739, 1045, 1412, 1847, 2344, 2909, 3539, 4234, 4993, 5815, 6692, 7627, 8612, 9642, 10716, 11826, 12964, 14129, 15313, 16505, 17707, 18904, 20090, 21265, 22413, 23531, 24615, 25654, 26642, 27575, 28446, 29248, 29979, 30632, 31204, 31693, 32091, 32400, 32617, 32739, 32769, 32762, 32735, 32680, 32593, 32468, 32300, 32088, 31829, 31517, 31154, 30739, 30271, 29748, 29171, 28542, 27863, 27134, 26355, 25531, 24664, 23758, 22818, 21843, 20838, 19812, 18763, 17698, 16625, 15544, 14464, 13390, 12323, 11270, 10240, 9232, 8255, 7315, 6412, 5553, 4744, 3985, 3286, 2647, 2068, 1557, 1116, 744, 446, 224, 76, 6, -1, 0, 0, 0, -1, 0, -1, -7, -18, -37, -66, -105, -156, -219, -293, -381, -486, -602, -732, -878, -1040, -1215, -1407, -1615, -1839, -2076, -2327, -2595, -2874, -3170, -3478, -3798, -4130, -4476, -4832, -5194, -5568, -5951, -6342, -6738, -7140, -7547, -7959, -8372, -8787, -9202, -9616, -10030, -10441, -10846, -11248, -11645, -12032, -12414, -12783, -13144, -13495, -13831, -14156, -14467, -14762, -15043, -15307, -15553, -15780, -15990, -16181, -16352, -16502, -16631, -16740, -16828, -16894, -16937, -16960, -16964, -16960, -16954, -16942, -16921, -16894, -16858, -16812, -16755, -16689, -16611, -16520, -16417, -16305, -16177, -16037, -15883, -15716, -15537, -15344, -15139, -14920, -14688, -14445, -14190, -13922, -13643, -13351, -13049, -12739, -12416, -12087, -11749, -11402, -11047, -10688, -10322, -9949, -9576, -9195, -8813, -8431, -8045, -7661, -7277, -6895, -6515, -6139, -5765, -5399, -5038, -4682, -4334, -3996, -3666, -3345, -3038, -2741, -2456, -2183, -1923, -1679, -1449, -1234, -1035, -852, -686, -538, -406, -293, -199, -122, -63, -23, -3, 0, -1, -1, 0, 0, 0, 0, 0};