/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0888 256 samples */
 
const int16_t AKWF_0888_256_DATA [256] = 
{255, 939, 1590, 2224, 2836, 3426, 3993, 4532, 5046, 5529, 5981, 6400, 6788, 7140, 7459, 7741, 7985, 8194, 8367, 8500, 8598, 8660, 8685, 8675, 8630, 8553, 8442, 8300, 8128, 7928, 7701, 7448, 7175, 6879, 6564, 6231, 5885, 5527, 5157, 4783, 4405, 4025, 3652, 3285, 2951, 2609, 2228, 1867, 1511, 1155, 800, 444, 83, -277, -637, -1000, -1359, -1716, -2069, -2414, -2754, -3085, -3405, -3712, -4008, -4289, -4553, -4800, -5028, -5238, -5427, -5594, -5739, -5861, -5961, -6035, -6087, -6113, -6115, -6092, -6045, -5975, -5879, -5761, -5621, -5458, -5276, -5072, -4851, -4612, -4358, -4089, -3809, -3519, -3224, -2924, -2628, -2380, -397, 346, 960, 1930, 2989, 4092, 5206, 6302, 7358, 8367, 9315, 10191, 10999, 11729, 12381, 12957, 13457, 13881, 14233, 14517, 14734, 14890, 14988, 15031, 15026, 14976, 14886, 14759, 14601, 14414, 14205, 13975, 13731, 13474, 13208, 12936, 12661, 12388, 12118, 11851, 11595, 11346, 11109, 10887, 10678, 10486, 10312, 10156, 10019, 9903, 9809, 9735, 9684, 9655, 9650, 9663, 9645, 9609, 9563, 9494, 9394, 9253, 9070, 8838, 8555, 8220, 7835, 7401, 6922, 6404, 5857, 5290, 4774, 4188, 3461, 2740, 1987, 1192, 353, -538, -1480, -2467, -3503, -4584, -5701, -6856, -8040, -9246, -10476, -11719, -12967, -14221, -15472, -16711, -17939, -19145, -20324, -21478, -22591, -23667, -24699, -25681, -26611, -27487, -28302, -29056, -29746, -30367, -30921, -31405, -31815, -32154, -32419, -32609, -32725, -32768, -32737, -32631, -32457, -32210, -31894, -31511, -31062, -30550, -29979, -29349, -28663, -27926, -27141, -26309, -25437, -24527, -23581, -22608, -21607, -20583, -19545, -18489, -17426, -16361, -15293, -14229, -13177, -12136, -11117, -10124, -9158, -8232, -7383, -6572, -5698, -4872, -4082, -3317, -2572, -1841, -1127, -413};