/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0824 256 samples */
 
const int16_t AKWF_0824_256_DATA [256] = 
{5046, 3428, 5842, 7643, 9319, 11023, 12746, 14437, 16067, 17615, 19068, 20433, 21717, 22915, 24040, 25093, 26074, 26991, 27845, 28624, 29327, 29948, 30494, 30971, 31375, 31712, 31986, 32204, 32373, 32500, 32590, 32645, 32670, 32667, 32636, 32579, 32500, 32396, 32271, 32126, 31960, 31774, 31572, 31351, 31115, 30864, 30598, 30319, 30028, 29725, 29412, 29094, 28753, 28621, 28734, 28762, 28771, 28763, 28747, 28721, 28677, 28854, 27802, 24510, 25030, 25531, 24137, 22859, 21704, 20470, 19173, 17861, 16565, 15312, 14120, 12983, 11904, 10882, 9904, 8961, 8072, 7074, 5641, 4267, 2957, 1669, 397, -873, -2138, -3391, -4632, -5847, -7036, -8193, -9307, -10374, -11396, -12364, -13285, -14160, -14989, -15777, -16525, -17232, -17897, -18517, -19086, -19599, -20050, -20435, -20752, -20996, -21164, -21265, -21306, -21296, -21253, -21036, -20531, -19905, -19270, -18630, -17994, -17365, -16748, -16142, -15550, -14973, -14406, -13856, -13323, -12805, -12306, -11826, -11365, -10929, -10518, -10132, -9776, -9450, -9154, -8888, -8650, -8438, -8233, -8206, -8494, -8733, -8957, -9174, -9386, -9594, -9799, -9999, -10195, -10386, -10572, -10753, -10928, -11097, -11261, -11418, -11568, -11714, -11853, -11986, -12111, -12228, -12337, -12436, -12522, -12593, -12643, -12669, -12668, -12641, -12589, -12514, -12416, -12300, -12168, -12037, -11913, -11799, -11695, -11600, -11514, -11439, -11372, -11308, -11239, -11166, -11084, -10993, -10891, -10779, -10657, -10523, -10381, -10230, -10070, -9901, -9725, -9544, -9355, -9161, -8961, -8758, -8542, -8427, -8581, -8873, -9175, -9486, -9800, -10117, -10434, -10751, -11068, -11384, -11698, -12010, -12319, -12621, -12911, -13185, -13439, -13663, -13855, -14008, -14118, -14179, -14190, -14149, -14055, -13912, -13718, -13479, -13195, -12869, -12505, -12101, -11663, -11187, -10710, -10007, -8882, -7842, -6844, -5876, -4929, -4006, -3100, -2495, -378, 2547};