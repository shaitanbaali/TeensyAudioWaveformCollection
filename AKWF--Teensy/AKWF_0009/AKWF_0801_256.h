/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0801 256 samples */
 
const int16_t AKWF_0801_256_DATA [256] = 
{132, 600, 1337, 2277, 3345, 4480, 5634, 6780, 7914, 9030, 10124, 11198, 12253, 13287, 14307, 15319, 16323, 17326, 18325, 19313, 20293, 21254, 22191, 23104, 23985, 24832, 25648, 26427, 27169, 27875, 28543, 29170, 29757, 30297, 30792, 31238, 31632, 31972, 32255, 32480, 32641, 32738, 32767, 32726, 32613, 32425, 32161, 31818, 31396, 30892, 30305, 29637, 28883, 28045, 27124, 26118, 25030, 23861, 22610, 21283, 19883, 18408, 16869, 15270, 13612, 11910, 10172, 8407, 6639, 4881, 3151, 1473, -141, -1684, -3145, -4526, -5825, -7037, -8168, -9212, -10166, -11032, -11806, -12484, -13073, -13571, -13981, -14312, -14566, -14749, -14869, -14930, -14941, -14906, -14831, -14723, -14587, -14430, -14257, -14073, -13884, -13692, -13498, -13305, -13112, -12913, -12707, -12484, -12234, -11946, -11608, -11213, -10762, -10271, -9806, -9466, -9311, -9350, -9546, -9836, -10147, -10420, -10618, -10730, -10765, -10745, -10696, -10641, -10592, -10553, -10518, -10475, -10413, -10321, -10192, -10025, -9822, -9585, -9324, -9042, -8740, -8427, -8100, -7759, -7407, -7043, -6669, -6287, -5898, -5506, -5114, -4722, -4334, -3951, -3573, -3200, -2833, -2470, -2111, -1756, -1399, -1040, -677, -302, 84, 483, 892, 1301, 1706, 2094, 2456, 2782, 3067, 3305, 3492, 3626, 3706, 3728, 3691, 3593, 3432, 3205, 2911, 2552, 2124, 1632, 1075, 457, -216, -947, -1727, -2552, -3420, -4321, -5254, -6212, -7186, -8173, -9167, -10157, -11140, -12108, -13052, -13970, -14851, -15688, -16478, -17214, -17886, -18495, -19032, -19493, -19876, -20176, -20392, -20520, -20559, -20509, -20367, -20135, -19813, -19401, -18901, -18316, -17645, -16895, -16067, -15164, -14195, -13164, -12074, -10943, -9777, -8591, -7412, -6260, -5165, -4160, -3261, -2482, -1823, -1271, -813, -436, -130, 110, 286, 416, 535, 621, 651, 604, 471, 249, 20, -45};