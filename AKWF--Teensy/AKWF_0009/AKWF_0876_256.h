/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0876 256 samples */
 
const int16_t AKWF_0876_256_DATA [256] = 
{581, 1388, 2120, 2801, 3430, 4011, 4547, 5037, 5471, 5948, 6667, 7486, 8391, 9256, 10077, 10913, 11802, 12757, 13769, 14820, 15905, 17011, 18128, 19256, 20383, 21499, 22602, 23680, 24729, 25748, 26725, 27660, 28551, 29389, 30173, 30900, 31563, 32180, 32651, 32772, 32689, 32412, 32067, 31666, 31146, 30472, 29631, 28634, 27500, 26237, 24860, 23382, 21804, 20141, 18408, 16606, 14752, 12854, 10914, 8948, 6964, 4961, 2959, 943, -869, -2430, -3843, -5151, -6449, -7700, -8841, -9857, -10563, -10885, -10937, -10948, -11121, -11314, -11440, -11358, -11102, -10747, -10344, -9916, -9443, -9039, -8890, -8847, -8906, -8946, -8960, -9015, -9148, -9370, -9672, -10039, -10464, -10937, -11450, -11999, -12577, -13173, -13785, -14403, -15020, -15654, -16150, -16366, -16432, -16388, -16610, -16978, -17396, -17723, -17899, -17987, -18051, -18116, -18183, -18248, -18295, -18069, -17647, -17080, -16439, -16001, -15753, -15535, -15284, -14893, -14414, -13911, -13446, -12842, -12003, -11054, -10020, -9017, -8027, -6984, -5858, -4647, -3359, -2007, -607, 837, 2317, 3821, 5348, 6884, 8418, 9952, 11474, 12974, 14457, 15908, 17324, 18704, 20035, 21333, 22506, 23339, 23975, 24423, 24805, 25136, 25354, 25416, 25311, 25047, 24640, 24100, 23437, 22661, 21778, 20796, 19731, 18586, 17363, 16109, 15073, 14153, 13328, 12494, 11610, 10740, 9932, 9213, 8579, 8020, 7518, 6812, 5983, 5076, 4175, 3340, 2518, 1650, 716, -278, -1326, -2417, -3537, -4687, -5858, -7041, -8233, -9427, -10612, -11788, -12949, -14086, -15203, -16283, -17358, -18677, -20117, -21644, -23157, -24588, -25740, -26743, -27652, -28551, -29492, -30423, -31109, -31424, -31495, -31353, -31124, -30790, -30289, -29593, -28706, -27642, -26417, -25054, -23556, -21943, -20216, -18448, -16884, -15400, -13984, -12531, -11024, -9525, -8095, -6749, -5487, -4303, -3190, -2146, -1172, -247};