/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0862 256 samples */
 
const int16_t AKWF_0862_256_DATA [256] = 
{1200, 3900, 5726, 7199, 8568, 10164, 11558, 12692, 13579, 14239, 14758, 15219, 15588, 15692, 15927, 15242, 6348, 1913, 2521, 2433, 3386, 4184, 5023, 6182, 7476, 8896, 10750, 12825, 14506, 15289, 16025, 17067, 18243, 19486, 20783, 22167, 24070, 18685, 12073, 13250, 13751, 15556, 10435, 3092, 185, -4504, -7871, -12090, -14804, -17745, -20267, -21871, -22982, -23553, -23687, -23429, -22922, -21543, -23606, -31765, -32119, -30741, -29497, -27282, -25248, -22780, -22339, -23191, -21633, -21160, -19953, -18733, -17363, -15928, -14523, -13152, -11869, -10848, -9682, -9433, -17403, -20935, -19454, -18691, -17080, -14612, -12375, -10204, -7687, -5358, -2737, -78, 2047, 3189, 4220, 5501, 6851, 8206, 9555, 10934, 12780, 7292, 528, 1528, 2034, 2858, 4028, 5016, 6094, 7197, 8407, 9999, 12308, 14197, 15492, 16516, 17334, 17984, 18527, 18982, 19258, 20041, 17086, 7803, 6143, 6061, 5728, 6268, 6604, 6925, 7251, 7537, 7856, 8460, 8882, 9054, 8979, 8669, 8218, 7698, 7081, 6192, 5422, 3728, -6181, -11639, -12060, -13182, -13269, -13516, -13727, -13620, -13381, -13018, -12226, -11213, -10593, -10877, -11204, -11225, -11115, -10932, -10693, -10368, -9520, -15956, -23620, -23447, -23525, -22915, -21763, -20518, -18098, -14506, -10070, -5090, 344, 4896, 8297, 10894, 12841, 14237, 15206, 15846, 16133, 16793, 13616, 4045, 2052, 1617, 917, 1094, 1093, 962, 1556, 2563, 2848, 3910, 4521, 4828, 4790, 4452, 3959, 3417, 2806, 1942, 1218, -408, -10225, -15565, -15838, -16781, -16661, -16665, -16604, -16197, -15627, -14904, -13724, -12295, -11237, -11051, -10892, -10398, -9751, -9012, -8199, -7275, -5812, -11614, -18628, -17812, -17430, -16671, -15504, -14462, -13274, -12008, -10580, -8718, -6089, -3830, -2118, -634, 692, 1897, 3031, 4121, 5069, 6564, 4358, -4142, -4987, -4212, -3719, -1984};