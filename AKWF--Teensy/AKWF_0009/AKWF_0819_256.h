/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0819 256 samples */
 
const int16_t AKWF_0819_256_DATA [256] = 
{1595, 4865, 7414, 9350, 10694, 11496, 11815, 11723, 11285, 10573, 9655, 8587, 7430, 6233, 5032, 3867, 2768, 1750, 831, 25, -669, -1245, -1708, -2063, -2317, -2477, -2554, -2561, -2507, -2402, -2257, -2082, -1887, -1680, -1465, -1251, -1045, -847, -663, -495, -343, -211, -97, 0, 79, 140, 185, 217, 239, 248, 247, 239, 226, 209, 187, 163, 137, 114, 90, 66, 44, 25, 8, -8, -20, -31, -158, 248, -1388, -23730, -31310, -24365, -19342, -11445, 360, 12488, 21755, 27099, 28937, 28118, 25498, 21755, 17413, 12867, 8386, 4191, 429, -2747, -6866, -11015, -13183, -14337, -14611, -13817, -12148, -10013, -7771, -5658, -3787, -2338, -167, -6953, -15992, -11944, -7700, -3552, 2623, 9483, 14914, 17942, 18676, 17651, 15468, 12608, 9444, 6248, 3193, 423, -1975, -3966, -5525, -6663, -7408, -7794, -7868, -7677, -7270, -6696, -6000, -5223, -4401, -3565, -2746, -1962, -1232, -570, 18, 525, 950, 1295, 1562, 1755, 1880, 1943, 1954, 1919, 1845, 1742, 1616, 1473, 1320, 1162, 1003, 847, 698, 557, 429, 313, 211, 122, 46, -16, -64, -104, -133, -151, -161, -165, -162, -153, -142, -129, -112, -96, -79, 115, -694, 3517, 22054, 23409, 17560, 13067, 5748, -4150, -13448, -19953, -23214, -23713, -22220, -19434, -15909, -12046, -8136, -4415, -1029, 1868, 4698, 3330, 703, 3366, 5477, 8721, 14848, 16850, 17016, 16271, 13857, 10357, 6834, 3778, 1362, -440, -1769, -2749, -3405, -3705, -4147, -4595, -4549, -3514, -3012, -2702, -1966, -1691, -1968, -2247, -2506, -2699, -2764, -2487, -1365, -549, 2, 554, 961, 1186, 1089, -463, 4354, 28705, 31089, 23680, 18175, 9004, -3718, -15888, -24578, -29130, -30113, -28501, -25182, -20865, -16070, -11174, -6474, -2099};