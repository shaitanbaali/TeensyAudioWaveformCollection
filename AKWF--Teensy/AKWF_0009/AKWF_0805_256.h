/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0805 256 samples */
 
const int16_t AKWF_0805_256_DATA [256] = 
{6260, 14726, 21082, 25817, 29142, 31282, 32436, 32767, 32429, 31547, 30253, 28518, 27465, 28528, 29822, 30384, 30178, 29269, 27769, 25777, 23395, 20706, 17805, 14744, 11603, 8437, 5282, 2189, -797, -3665, -6372, -8905, -11254, -13399, -15328, -17047, -18544, -19828, -20897, -21753, -22409, -22866, -23138, -23231, -23161, -22938, -22566, -22069, -21455, -20731, -19913, -19016, -18049, -17018, -15943, -14835, -13696, -12538, -11371, -10203, -9045, -7894, -6770, -5669, -4598, -3564, -2565, -1609, -705, 156, 969, 1726, 2435, 3091, 3696, 4249, 4748, 5195, 5594, 5950, 6253, 6512, 6731, 6906, 7043, 7142, 7207, 7238, 7240, 7216, 7165, 7089, 6993, 6879, 6749, 6606, 6444, 6277, 6102, 5915, 5724, 5533, 5339, 5145, 4946, 4754, 4565, 4387, 4211, 4042, 3890, 3750, 3630, 3530, 3471, 3466, 3480, 3897, 5762, 6675, 6348, 6037, 5826, 5568, 5152, 4522, 3689, 2694, 1581, 404, -781, -1942, -3029, -4024, -4918, -5676, -6306, -6793, -7146, -7366, -7466, -7438, -7305, -7072, -6755, -6359, -5899, -5386, -4829, -4241, -3631, -3003, -2372, -1746, -1130, -525, 55, 610, 1132, 1628, 2081, 2502, 2878, 3217, 3514, 3768, 3981, 4155, 4289, 4386, 4446, 4467, 4462, 4421, 4352, 4254, 4135, 3992, 3831, 3650, 3452, 3243, 3027, 2798, 2560, 2317, 2076, 1827, 1583, 1337, 1095, 861, 628, 402, 181, -29, -235, -426, -609, -784, -945, -1100, -1241, -1371, -1490, -1599, -1699, -1785, -1867, -1933, -1993, -2037, -2078, -2108, -2131, -2146, -2156, -2151, -2148, -2139, -2119, -2097, -2067, -2037, -2000, -1964, -1924, -1878, -1831, -1785, -1732, -1678, -1627, -1574, -1518, -1464, -1409, -1360, -1307, -1265, -2270, -4818, -6845, -8429, -11855, -21687, -28733, -29545, -29487, -29374, -28694, -26953, -23909, -19782, -13654, -3522};