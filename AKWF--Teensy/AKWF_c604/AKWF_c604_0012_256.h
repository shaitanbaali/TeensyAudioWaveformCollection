/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_c604_0012 256 samples */
 
const int16_t AKWF_c604_0012_256_DATA [256] = 
{30171, 30242, 30234, 30237, 30236, 30236, 30237, 30237, 30236, 30236, 30236, 30236, 30236, 30236, 30236, 30237, 30236, 30236, 30237, 30237, 30237, 30236, 30236, 30237, 30236, 30236, 30236, 30236, 30237, 30236, 30236, 30236, 30236, 30236, 30237, 30237, 30236, 30236, 30237, 30236, 30236, 30237, 30236, 30236, 30236, 30237, 30236, 30236, 30236, 30237, 30237, 30236, 30236, 30236, 30236, 30236, 30236, 30236, 30236, 30236, 30236, 30236, 30236, 30236, 30236, 30237, 30237, 30236, 30236, 30236, 30236, 30236, 30236, 30236, 30236, 30236, 30236, 30236, 30236, 30236, 30236, 30236, 30237, 30236, 30236, 30236, 30236, 30236, 30236, 30236, 30236, 30236, 30236, 30237, 30236, 30236, 30237, 30237, 30236, 30237, 30236, 30236, 30236, 30236, 30237, 30237, 30236, 30236, 30236, 30236, 30237, 30236, 30236, 30236, 30237, 30236, 30236, 30237, 30237, 30236, 30236, 30237, 30236, 30236, 30236, 30230, 30264, 30051, 29845, 29879, 29872, 29873, 29873, 29873, 29873, 29873, 29872, 29872, 29872, 29873, 29873, 29872, 29872, 29873, 29872, 29872, 29872, 29873, 29873, 29873, 29872, 29872, 29877, 28945, 34016, -8535, -34334, -29319, -30242, -30235, -30235, -30236, -30237, -30237, -30236, -30236, -30236, -30236, -30236, -30236, -30236, -30236, -30237, -30235, -30236, -30236, -30237, -30237, -30236, -30236, -30236, -30236, -30236, -30236, -30236, -30236, -30236, -30237, -30237, -30237, -30237, -30236, -30236, -30237, -30236, -30237, -30237, -30236, -30236, -30236, -30237, -30237, -30237, -30236, -30236, -30236, -30236, -30236, -30236, -30236, -30237, -30235, -30243, -30212, -29894, -29867, -29874, -29873, -29872, -29873, -29873, -29873, -29872, -29873, -29873, -29872, -29873, -29872, -29873, -29873, -29873, -29873, -29873, -29873, -29873, -29873, -29873, -29873, -29873, -29872, -29873, -29873, -29872, -29872, -29872, -29873, -29873, -29873, -29873, -29873, -29873, -29873, -29870, -29778, -30298, -27951};