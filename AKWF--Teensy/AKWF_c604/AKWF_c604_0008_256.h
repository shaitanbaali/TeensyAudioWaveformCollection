/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_c604_0008 256 samples */
 
const int16_t AKWF_c604_0008_256_DATA [256] = 
{7391, 22012, 29993, 32251, 31096, 28473, 26058, 24532, 23923, 23916, 24244, 24626, 24852, 25050, 25037, 25039, 25045, 25023, 24774, 24751, 24757, 24761, 24734, 24887, 25061, 25035, 25037, 25053, 24984, 24748, 24757, 24756, 24759, 24737, 24940, 25059, 25036, 25036, 25059, 24936, 24736, 24760, 24755, 24756, 24756, 24756, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24756, 24756, 24756, 24756, 24756, 24756, 24756, 24756, 24756, 24756, 24756, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24755, 24756, 24756, 24737, 24689, 24867, 17848, 2423, -12937, -24467, -30734, -32683, -31634, -29422, -27146, -25379, -24392, -24155, -24241, -24512, -24854, -25173, -25341, -25320, -25325, -25322, -25334, -25284, -25041, -25039, -25041, -25042, -25032, -25073, -25319, -25327, -25324, -25323, -25331, -25299, -25052, -25037, -25041, -25041, -25035, -25059, -25307, -25330, -25323, -25323, -25329, -25312, -25064, -25034, -25042, -25041, -25040, -25040, -25040, -25040, -25040, -25040, -25040, -25040, -25040, -25040, -25040, -25040, -25041, -25040, -25040, -25041, -25039, -24942, -25329, -22544, -9292};