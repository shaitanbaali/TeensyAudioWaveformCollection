/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_c604_0015 256 samples */
 
const int16_t AKWF_c604_0015_256_DATA [256] = 
{5324, 14427, 21649, 27098, 30474, 32121, 32481, 31912, 30660, 29201, 27646, 26336, 25196, 24523, 23919, 23749, 23781, 23762, 23977, 24243, 24427, 24653, 24775, 25015, 25003, 25005, 25005, 25005, 25005, 25005, 25002, 25019, 24946, 24689, 24698, 24697, 24696, 24697, 24696, 24696, 24701, 24676, 24813, 25026, 25000, 25005, 25005, 25006, 25005, 25005, 25001, 25025, 24903, 24677, 24701, 24696, 24696, 24697, 24696, 24696, 24701, 24674, 24861, 25028, 24999, 25004, 25005, 25005, 25005, 25005, 25000, 25028, 24855, 24673, 24702, 24697, 24696, 24696, 24696, 24696, 24696, 24696, 24697, 24697, 24697, 24697, 24697, 24697, 24697, 24697, 24697, 24697, 24697, 24697, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24696, 24666, 24762, 24054, 20157, 13945, 6611, -846, -8156, -14895, -20689, -25310, -28679, -30967, -32211, -32699, -32388, -31720, -30632, -29371, -28412, -27232, -26154, -25295, -24647, -24130, -23830, -23760, -23774, -23774, -23763, -23989, -24184, -24376, -24543, -24715, -24710, -24984, -25011, -25004, -25005, -25005, -25005, -25005, -25005, -25005, -25005, -25000, -25028, -24872, -24674, -24702, -24697, -24697, -24698, -24696, -24696, -24697, -24696, -24697, -24702, -24665, -24889, -24935, -22669, -17515, -10733, -3107};