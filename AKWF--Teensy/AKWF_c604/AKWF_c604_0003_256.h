/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_c604_0003 256 samples */
 
const int16_t AKWF_c604_0003_256_DATA [256] = 
{25848, 26057, 26012, 26020, 26020, 26019, 26020, 26021, 26020, 26020, 26020, 26021, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26021, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26021, 26021, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26021, 26020, 26020, 26020, 26020, 26021, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26021, 26020, 26021, 26020, 26020, 26021, 26021, 26020, 26021, 26020, 26020, 26021, 26021, 26021, 26021, 26021, 26021, 26020, 26020, 26021, 26020, 26020, 26020, 26021, 26020, 26020, 26021, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26020, 26021, 26020, 26020, 26020, 26021, 26020, 26021, 26021, 26020, 26020, 26020, 26020, 26021, 26020, 26019, 26019, 26021, 26023, 26019, 25687, 27544, 19858, -25410, -26277, -25903, -26024, -26022, -26020, -26019, -26020, -26021, -26021, -26020, -26020, -26021, -26020, -26021, -26021, -26020, -26020, -26020, -26020, -26020, -26020, -26020, -26020, -26020, -26021, -26021, -26020, -26020, -26021, -26021, -26020, -26021, -26021, -26020, -26021, -26021, -26021, -26020, -26020, -26020, -26020, -26021, -26021, -26021, -26020, -26020, -26021, -26021, -26020, -26020, -26020, -26020, -26021, -26021, -26020, -26020, -26020, -26020, -26021, -26021, -26020, -26020, -26021, -26020, -26020, -26021, -26020, -26021, -26021, -26021, -26020, -26021, -26021, -26021, -26021, -26020, -26020, -26021, -26021, -26021, -26021, -26021, -26020, -26021, -26021, -26021, -26020, -26020, -26020, -26020, -26021, -26021, -26020, -26021, -26020, -26020, -26017, -26032, -25956};