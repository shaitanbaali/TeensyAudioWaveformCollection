/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_c604_0030 256 samples */
 
const int16_t AKWF_c604_0030_256_DATA [256] = 
{22317, 18766, 9247, 1327, 7213, 2032, 511, 657, 8565, 897, 897, 385, 2061, -70, 135, -757, 17528, 11494, 5370, 2692, 6426, 1476, 1188, -413, 7339, 824, -194, 25, 0, 27, -175, 693, 4653, -86, 8, 5, 0, 0, 0, 0, 0, 0, 0, 0, 0, 4, 35, -333, 10566, 4379, 1759, 334, 974, -137, 37, -27, 992, 28, -8, 0, 0, 8, -68, 270, 729, -120, 26, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -10, 37, 558, -31, 7, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -5, -219, 1028, -14419, -22542, -21104, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21362, -21131, -22377, -15695};