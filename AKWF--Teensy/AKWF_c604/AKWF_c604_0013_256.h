/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_c604_0013 256 samples */
 
const int16_t AKWF_c604_0013_256_DATA [256] = 
{29, 227, 597, 1134, 1809, 2579, 3391, 4188, 4925, 5572, 6109, 6547, 6908, 7225, 7539, 7888, 8299, 8790, 9360, 9994, 10670, 11356, 12020, 12643, 13206, 13705, 14147, 14550, 14931, 15315, 15721, 16166, 16659, 17202, 17794, 18427, 19090, 19775, 20469, 21161, 21844, 22507, 23138, 23731, 24277, 24775, 25225, 25636, 26021, 26400, 26797, 27233, 27729, 28293, 28922, 29601, 30297, 30965, 31560, 32029, 32329, 32431, 32326, 32018, 31537, 30927, 30240, 29530, 28846, 28223, 27679, 27219, 26822, 26462, 26109, 25725, 25286, 24781, 24205, 23573, 22909, 22239, 21590, 20989, 20445, 19964, 19540, 19150, 18775, 18391, 17974, 17509, 16988, 16408, 15777, 15107, 14408, 13702, 12999, 12309, 11647, 11018, 10427, 9881, 9377, 8916, 8492, 8096, 7713, 7325, 6912, 6455, 5940, 5356, 4708, 4010, 3284, 2563, 1888, 1289, 798, 428, 178, 31, -47, -100, -176, -319, -566, -933, -1420, -2010, -2671, -3360, -4039, -4668, -5228, -5710, -6125, -6496, -6857, -7239, -7674, -8176, -8749, -9383, -10052, -10726, -11373, -11966, -12490, -12947, -13347, -13715, -14083, -14483, -14937, -15461, -16052, -16697, -17373, -18044, -18683, -19266, -19779, -20222, -20612, -20970, -21329, -21719, -22163, -22678, -23265, -23914, -24609, -25327, -26042, -26739, -27406, -28037, -28640, -29224, -29795, -30359, -30912, -31440, -31920, -32320, -32609, -32757, -32741, -32554, -32200, -31703, -31091, -30406, -29689, -28976, -28291, -27655, -27066, -26513, -25983, -25450, -24896, -24308, -23677, -23007, -22308, -21595, -20885, -20198, -19546, -18936, -18373, -17853, -17371, -16921, -16494, -16086, -15692, -15308, -14933, -14562, -14186, -13799, -13391, -12948, -12464, -11935, -11359, -10745, -10101, -9441, -8783, -8135, -7504, -6891, -6288, -5682, -5062, -4415, -3737, -3037, -2325, -1634, -996, -445, -16, 272, 414, 423, 332, 188, 52, -14};