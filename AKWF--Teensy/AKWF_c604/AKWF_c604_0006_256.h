/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_c604_0006 256 samples */
 
const int16_t AKWF_c604_0006_256_DATA [256] = 
{17323, 28008, 24837, 25231, 25870, 25042, 25765, 25289, 25471, 25560, 25268, 25668, 25261, 25589, 25398, 25429, 25546, 25320, 25597, 25333, 25532, 25433, 25418, 25535, 25349, 25560, 25370, 25501, 25452, 25414, 25525, 25369, 25535, 25394, 25482, 25462, 25414, 25516, 25384, 25518, 25411, 25470, 25468, 25415, 25509, 25396, 25503, 25424, 25460, 25473, 25417, 25502, 25406, 25492, 25434, 25453, 25474, 25419, 25496, 25415, 25483, 25441, 25449, 25476, 25422, 25489, 25423, 25476, 25447, 25446, 25475, 25426, 25483, 25429, 25469, 25452, 25445, 25473, 25430, 25478, 25436, 25464, 25454, 25444, 25471, 25435, 25473, 25441, 25460, 25457, 25444, 25468, 25438, 25468, 25445, 25457, 25457, 25446, 25466, 25443, 25464, 25448, 25456, 25457, 25448, 25462, 25446, 25460, 25452, 25454, 25456, 25451, 25458, 25450, 25457, 25453, 25455, 25454, 25454, 25455, 25454, 25455, 25453, 25456, 25452, 25457, 25451, 25457, 25453, 25453, 25458, 25448, 25461, 25447, 25460, 25452, 25452, 25461, 25444, 25466, 25444, 25461, 25452, 25450, 25464, 25440, 25469, 25441, 25463, 25454, 25446, 25469, 25435, 25474, 25439, 25462, 25456, 25443, 25474, 25430, 25477, 25437, 25461, 25460, 25437, 25480, 25425, 25481, 25436, 25459, 25465, 25431, 25487, 25419, 25484, 25437, 25455, 25471, 25423, 25495, 25414, 25486, 25438, 25449, 25480, 25412, 25505, 25405, 25501, 25193, 25141, 25203, 25116, 25220, 25116, 25197, 25159, 25144, 25212, 25102, 25232, 25109, 25197, 25166, 25130, 25229, 25084, 25245, 25104, 25194, 25178, 25110, 25253, 25063, 25262, 25097, 25187, 25198, 25080, 25288, 25029, 25285, 25091, 25171, 25235, 25025, 25352, 24970, 25324, 25088, 25126, 25337, 24875, 25526, 24818, 25366, 25327, 23760, 29757, 7936, -30598, -23881, -26020, -25142, -25581, -25432, -25436, -25479, -25430, -25503, -25338, -25693, -25060, -25978, -24673, -27895};