/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_c604_0011 256 samples */
 
const int16_t AKWF_c604_0011_256_DATA [256] = 
{19657, 27924, 26125, 26445, 26454, 26455, 26454, 26453, 26453, 26454, 26454, 26453, 26454, 26453, 26453, 26454, 26454, 26454, 26453, 26453, 26453, 26454, 26453, 26454, 26453, 26453, 26453, 26454, 26454, 26454, 26453, 26454, 26453, 26454, 26453, 26454, 26454, 26454, 26454, 26454, 26454, 26454, 26454, 26454, 26454, 26454, 26454, 26453, 26454, 26453, 26453, 26454, 26454, 26454, 26453, 26453, 26453, 26454, 26454, 26454, 26454, 26453, 26453, 26454, 26454, 26454, 26454, 26454, 26454, 26453, 26453, 26453, 26453, 26453, 26454, 26454, 26454, 26454, 26454, 26454, 26453, 26453, 26454, 26454, 26453, 26454, 26454, 26454, 26454, 26454, 26453, 26453, 26453, 26453, 26453, 26453, 26453, 26454, 26454, 26454, 26454, 26453, 26453, 26454, 26454, 26454, 26453, 26454, 26454, 26454, 26454, 26454, 26454, 26454, 26453, 26453, 26453, 26453, 26453, 26454, 26454, 26454, 26454, 26454, 26454, 26454, 26453, 26454, 26454, 26453, 26454, 26454, 26453, 26453, 26453, 26454, 26454, 26454, 26454, 26453, 26453, 26454, 26454, 26453, 26453, 26454, 26454, 26453, 26453, 26454, 26454, 26454, 26454, 26454, 26454, 26454, 26454, 26453, 26454, 26454, 26454, 26454, 26454, 26454, 26453, 26453, 26453, 26453, 26454, 26453, 26453, 26453, 26454, 26454, 26454, 26453, 26453, 26455, 26455, 26453, 26451, 26457, 25633, 30135, 7260, -30536, -25897, -26771, -26752, -26752, -26754, -26756, -26755, -26754, -26754, -26754, -26754, -26754, -26754, -26754, -26754, -26754, -26754, -26754, -26755, -26754, -26754, -26754, -26754, -26754, -26754, -26754, -26754, -26754, -26754, -26754, -26754, -26754, -26755, -26755, -26755, -26755, -26754, -26754, -26754, -26754, -26754, -26755, -26754, -26754, -26754, -26754, -26754, -26754, -26754, -26755, -26755, -26754, -26754, -26754, -26755, -26754, -26754, -26754, -26754, -26753, -26754, -26755, -26755, -26754, -26753, -26754, -26758, -26841, -26352, -28435};