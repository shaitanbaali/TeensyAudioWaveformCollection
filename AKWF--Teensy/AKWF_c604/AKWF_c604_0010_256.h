/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_c604_0010 256 samples */
 
const int16_t AKWF_c604_0010_256_DATA [256] = 
{4913, 14094, 21477, 26989, 30632, 32397, 32751, 32289, 31082, 29667, 28075, 26671, 25568, 24729, 24265, 23991, 23927, 23998, 24258, 24417, 24667, 24924, 24990, 25277, 25300, 25295, 25296, 25297, 25297, 25296, 25293, 25310, 25242, 24955, 24959, 24959, 24958, 24959, 24959, 24959, 24963, 24940, 25047, 25312, 25293, 25296, 25296, 25296, 25297, 25297, 25294, 25306, 25254, 24962, 24957, 24960, 24959, 24958, 24958, 24959, 24963, 24942, 25034, 25308, 25294, 25296, 25296, 25297, 25296, 25296, 25294, 25304, 25264, 24971, 24955, 24959, 24958, 24958, 24958, 24958, 24958, 24958, 24958, 24958, 24958, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24959, 24958, 24958, 24958, 24958, 24958, 24958, 24958, 24958, 24958, 24958, 24958, 24958, 24958, 24958, 24958, 24959, 24959, 24959, 24959, 24958, 24958, 24958, 24959, 24959, 24958, 24958, 24927, 25018, 24384, 19279, 10572, 683, -8822, -17261, -23936, -28668, -31577, -32658, -32658, -31873, -30511, -29050, -27457, -26192, -25202, -24486, -24151, -23939, -23926, -24119, -24306, -24523, -24777, -24955, -25097, -25322, -25291, -25297, -25297, -25296, -25296, -25297, -25291, -25322, -25114, -24934, -24965, -24959, -24959, -24959, -24959, -24959, -24964, -24938, -25182, -25319, -25292, -25297, -25296, -25297, -25296, -25297, -25290, -25322, -25128, -24933, -24965, -24959, -24959, -24959, -24959, -24959, -24965, -24935, -25167, -25320, -25291, -25297, -25297, -25296, -25297, -25297, -25290, -25322, -25143, -24933, -24958, -24922, -25027, -22263, -14859, -5112};