/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_c604_0007 256 samples */
 
const int16_t AKWF_c604_0007_256_DATA [256] = 
{27162, 30259, 29560, 29682, 29687, 29687, 29687, 29686, 29686, 29687, 29686, 29686, 29687, 29686, 29686, 29687, 29687, 29687, 29687, 29687, 29687, 29687, 29687, 29686, 29687, 29686, 29686, 29686, 29686, 29686, 29686, 29686, 29687, 29686, 29687, 29687, 29686, 29686, 29686, 29686, 29686, 29686, 29686, 29687, 29687, 29687, 29686, 29687, 29687, 29686, 29687, 29686, 29687, 29686, 29687, 29686, 29687, 29687, 29687, 29687, 29686, 29687, 29686, 29686, 29686, 29687, 29686, 29686, 29687, 29686, 29686, 29686, 29686, 29686, 29686, 29687, 29687, 29686, 29687, 29686, 29686, 29686, 29686, 29686, 29687, 29686, 29686, 29687, 29687, 29686, 29686, 29687, 29686, 29686, 29687, 29686, 29686, 29686, 29687, 29686, 29686, 29687, 29686, 29687, 29687, 29686, 29686, 29687, 29686, 29687, 29687, 29686, 29687, 29686, 29687, 29687, 29686, 29687, 29687, 29687, 29686, 29687, 29686, 29686, 29687, 29687, 29687, 29686, 29686, 29681, 29707, 29449, 29329, 29355, 29349, 29349, 29349, 29349, 29349, 29350, 29350, 29350, 29349, 29349, 29349, 29349, 29350, 29349, 29349, 29349, 29350, 29350, 29349, 29349, 29349, 29351, 28521, 33096, 11016, -33489, -28841, -29694, -29686, -29686, -29686, -29687, -29687, -29687, -29686, -29687, -29687, -29687, -29686, -29686, -29687, -29686, -29687, -29686, -29686, -29687, -29687, -29687, -29686, -29686, -29686, -29686, -29686, -29687, -29687, -29687, -29687, -29686, -29687, -29687, -29686, -29686, -29687, -29686, -29687, -29686, -29687, -29687, -29686, -29687, -29686, -29687, -29686, -29687, -29687, -29686, -29687, -29687, -29686, -29686, -29686, -29686, -29687, -29687, -29686, -29686, -29686, -29687, -29687, -29687, -29686, -29687, -29687, -29686, -29686, -29687, -29686, -29687, -29687, -29687, -29687, -29687, -29686, -29687, -29687, -29687, -29687, -29687, -29687, -29687, -29687, -29687, -29687, -29687, -29687, -29687, -29687, -29687, -29686, -29659, -29813, -29135};