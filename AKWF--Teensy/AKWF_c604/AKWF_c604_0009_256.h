/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_c604_0009 256 samples */
 
const int16_t AKWF_c604_0009_256_DATA [256] = 
{7168, 21772, 30599, 32723, 29683, 24797, 21382, 21126, 23517, 26564, 28218, 27630, 25494, 23412, 22754, 23800, 25677, 27043, 27022, 25747, 24182, 23418, 23917, 25253, 26456, 26705, 25886, 24624, 23814, 23994, 24989, 26072, 26486, 25973, 24928, 24102, 24060, 24803, 25783, 26309, 26026, 25160, 24336, 24129, 24665, 25549, 26149, 26054, 25347, 24541, 24204, 24563, 25349, 26000, 26059, 25499, 24725, 24288, 24487, 25174, 25853, 26046, 25625, 24896, 24379, 24436, 25019, 25709, 26015, 25728, 25056, 24481, 24407, 24883, 25564, 25968, 25810, 25207, 24590, 24397, 24761, 25421, 25905, 25873, 25349, 24708, 24406, 24656, 25278, 25828, 25917, 25481, 24833, 24434, 24565, 25135, 25737, 25942, 25605, 24966, 24478, 24491, 24996, 25632, 25949, 25718, 25104, 24542, 24433, 24858, 25515, 25937, 25821, 25247, 24622, 24392, 24723, 25385, 25905, 25912, 25396, 24721, 24368, 24593, 25242, 25855, 25991, 25550, 24837, 24361, 24467, 25085, 25782, 26058, 25709, 24974, 24375, 24344, 24913, 25687, 26111, 25875, 25134, 24410, 24224, 24723, 25564, 26150, 26051, 25322, 24470, 24106, 24508, 25409, 26174, 26245, 25548, 24559, 23984, 24255, 25210, 26182, 26469, 25831, 24688, 23849, 23939, 24941, 26175, 26753, 26213, 24879, 23677, 23497, 24548, 26152, 27172, 26803, 25188, 23400, 22749, 23855, 26110, 27982, 27999, 25841, 22743, 20882, 21991, 26033, 30795, 32770, 28922, 18418, 3226, -12641, -24907, -31063, -31228, -27774, -23895, -21951, -22539, -24638, -26587, -27203, -26392, -24968, -23967, -23949, -24735, -25658, -26090, -25845, -25219, -24700, -24607, -24905, -25305, -25515, -25448, -25236, -25077, -25068, -25145, -25181, -25126, -25058, -25103, -25289, -25485, -25492, -25218, -24811, -24586, -24794, -25379, -25957, -26049, -25461, -24504, -23862, -24128, -25309, -26685, -27200, -26209, -24082, -22201, -22179, -24719, -28765, -31637, -30202, -22516, -8746};