/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_c604_0032 256 samples */
 
const int16_t AKWF_c604_0032_256_DATA [256] = 
{39, 5, -2, 0, 0, 0, -1, 2, 12, -2, 0, 0, 0, 0, -8, 28, 420, -24, 5, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 14, -60, 622, 88, -23, 1, 0, 2, -36, 138, 711, -84, 32, -47, 753, 301, 419, 2025, 4558, -437, 88, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 24, -101, 1046, 148, -38, 2, 0, 4, -56, 219, 1125, -132, 50, -73, 1163, 491, 467, 3854, 7670, -835, 165, 0, 0, 0, 9, -38, 1412, 43, -56, 180, 1434, -90, 2569, 4579, 7039, -734, 143, 30, 1609, -25, 662, 6134, 10836, -1301, 1271, 8749, 11022, 10189, 19579, 30445, -589, -37037, -31840, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32625, -33390, -29290};