/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_c604_0027 256 samples */
 
const int16_t AKWF_c604_0027_256_DATA [256] = 
{149, 410, 666, 924, 1179, 1435, 1694, 1949, 2206, 2463, 2720, 2978, 3233, 3490, 3747, 4005, 4260, 4517, 4774, 5031, 5288, 5545, 5800, 6059, 6316, 6572, 6829, 7085, 7342, 7599, 7856, 8112, 8369, 8626, 8882, 9140, 9397, 9652, 9910, 10167, 10424, 10679, 10935, 11194, 11451, 11707, 11963, 12221, 12478, 12734, 12992, 13248, 13504, 13763, 14017, 14276, 14533, 14789, 15046, 15302, 15559, 15817, 16072, 16329, 16587, 16844, 17100, 17357, 17613, 17870, 18129, 18383, 18640, 18899, 19154, 19411, 19668, 19924, 20183, 20439, 20694, 20952, 21208, 21467, 21722, 21979, 22235, 22493, 22751, 23005, 23264, 23519, 23776, 24035, 24290, 24546, 24803, 25061, 25317, 25574, 25831, 26088, 26344, 26602, 26856, 27116, 27372, 27628, 27886, 28142, 28399, 28656, 28912, 29169, 29426, 29683, 29939, 30196, 30453, 30710, 30968, 31223, 31480, 31738, 31993, 31548, 35527, 16923, -33377, -32370, -32045, -31923, -31665, -31408, -31153, -30897, -30639, -30381, -30124, -29870, -29611, -29355, -29098, -28840, -28586, -28328, -28070, -27814, -27558, -27301, -27044, -26788, -26530, -26273, -26019, -25760, -25503, -25248, -24990, -24734, -24476, -24220, -23963, -23706, -23451, -23192, -22936, -22679, -22422, -22165, -21908, -21652, -21395, -21138, -20882, -20624, -20368, -20111, -19854, -19598, -19340, -19085, -18827, -18570, -18314, -18056, -17801, -17543, -17286, -17030, -16772, -16516, -16259, -16002, -15746, -15488, -15232, -14976, -14718, -14464, -14204, -13948, -13691, -13434, -13179, -12920, -12665, -12408, -12151, -11895, -11636, -11381, -11124, -10867, -10611, -10353, -10097, -9841, -9584, -9327, -9069, -8814, -8556, -8299, -8042, -7786, -7529, -7273, -7015, -6759, -6502, -6246, -5989, -5730, -5475, -5217, -4962, -4703, -4447, -4192, -3934, -3678, -3420, -3164, -2907, -2650, -2394, -2137, -1880, -1624, -1366, -1109, -852, -596, -340, -78};