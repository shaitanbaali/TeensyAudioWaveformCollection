/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_c604_0005 256 samples */
 
const int16_t AKWF_c604_0005_256_DATA [256] = 
{11006, 23452, 30390, 32644, 32017, 29883, 27565, 25794, 24840, 24311, 24465, 24778, 25088, 25309, 25558, 25592, 25584, 25583, 25599, 25528, 25270, 25279, 25278, 25279, 25271, 25303, 25572, 25590, 25585, 25585, 25586, 25585, 25322, 25268, 25280, 25281, 25269, 25313, 25581, 25588, 25585, 25585, 25588, 25578, 25309, 25270, 25280, 25278, 25278, 25278, 25278, 25278, 25278, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25277, 25278, 25278, 25278, 25278, 25278, 25278, 25278, 25278, 25278, 25278, 25278, 25278, 25278, 25278, 25278, 25278, 25278, 25278, 25278, 25278, 25278, 25278, 25278, 25278, 25278, 25278, 25278, 25278, 25278, 25278, 25278, 25278, 25278, 25278, 25278, 25278, 25278, 25266, 25192, 25488, 19335, 4265, -11210, -23239, -30206, -32622, -32131, -30162, -27738, -25960, -24841, -24383, -24385, -24695, -24991, -25297, -25576, -25588, -25585, -25585, -25587, -25584, -25319, -25268, -25280, -25279, -25283, -25256, -25403, -25609, -25581, -25586, -25582, -25604, -25505, -25263, -25281, -25278, -25280, -25267, -25322, -25586, -25587, -25586, -25585, -25589, -25572, -25302, -25272, -25280, -25278, -25278, -25278, -25278, -25278, -25278, -25278, -25277, -25278, -25278, -25278, -25278, -25278, -25278, -25278, -25278, -25278, -25275, -25289, -25039, -24954, -24973, -24970, -24882, -25144, -23535, -9770};