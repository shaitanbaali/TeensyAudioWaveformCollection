/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_c604_0001 256 samples */
 
const int16_t AKWF_c604_0001_256_DATA [256] = 
{28884, 27501, 27825, 27770, 27767, 27766, 27767, 27768, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27768, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27768, 27767, 27767, 27767, 27767, 27767, 27767, 27767, 27768, 27767, 27768, 27767, 27767, 27767, 27768, 27768, 27766, 27765, 27776, 26813, 31976, -5580, -32170, -27159, -28090, -28081, -28082, -28083, -28083, -28083, -28082, -28082, -28083, -28083, -28083, -28083, -28083, -28082, -28083, -28083, -28083, -28083, -28083, -28083, -28082, -28083, -28084, -28083, -28083, -28083, -28083, -28083, -28083, -28083, -28083, -28083, -28083, -28083, -28083, -28083, -28083, -28083, -28083, -28083, -28083, -28083, -28083, -28084, -28083, -28082, -28083, -28083, -28083, -28083, -28082, -28082, -28082, -28083, -28083, -28083, -28083, -28083, -28083, -28082, -28083, -28083, -28083, -28084, -28083, -28076, -27866, -29058, -23680};