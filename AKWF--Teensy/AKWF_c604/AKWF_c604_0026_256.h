/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_c604_0026 256 samples */
 
const int16_t AKWF_c604_0026_256_DATA [256] = 
{149, 669, 1182, 1695, 2208, 2720, 3234, 3745, 4260, 4774, 5285, 5797, 6313, 6826, 7339, 7851, 8363, 8877, 9391, 9903, 10415, 10930, 11443, 11957, 12469, 12982, 13495, 14008, 14520, 15035, 15547, 16059, 16573, 17086, 17600, 18113, 18624, 19138, 19653, 20165, 20677, 21192, 21704, 22218, 22730, 23242, 23756, 24269, 24783, 25295, 25809, 26322, 26836, 27348, 27860, 28374, 28887, 29399, 29914, 30427, 30937, 31452, 31956, 32511, 32643, 32119, 31608, 31097, 30583, 30071, 29557, 29044, 28530, 28017, 27506, 26992, 26478, 25966, 25453, 24939, 24428, 23913, 23400, 22888, 22375, 21861, 21349, 20835, 20321, 19810, 19296, 18782, 18271, 17757, 17245, 16731, 16218, 15705, 15191, 14678, 14165, 13653, 13139, 12628, 12114, 11600, 11088, 10574, 10060, 9548, 9034, 8522, 8009, 7496, 6982, 6470, 5957, 5444, 4930, 4418, 3904, 3393, 2879, 2365, 1853, 1339, 826, 313, -199, -712, -1225, -1739, -2250, -2764, -3278, -3790, -4304, -4816, -5329, -5842, -6357, -6868, -7380, -7894, -8409, -8921, -9434, -9946, -10461, -10974, -11486, -11999, -12512, -13024, -13540, -14052, -14564, -15077, -15590, -16103, -16617, -17129, -17641, -18155, -18669, -19182, -19695, -20207, -20720, -21235, -21747, -22259, -22773, -23287, -23800, -24313, -24824, -25338, -25851, -26364, -26878, -27391, -27903, -28416, -28930, -29443, -29956, -30468, -30980, -31495, -31999, -32552, -32650, -32117, -31607, -31095, -30583, -30071, -29556, -29043, -28530, -28018, -27505, -26990, -26478, -25966, -25453, -24940, -24427, -23914, -23400, -22888, -22375, -21860, -21348, -20835, -20323, -19810, -19297, -18783, -18270, -17757, -17245, -16730, -16216, -15705, -15192, -14678, -14166, -13653, -13138, -12627, -12112, -11599, -11087, -10574, -10061, -9549, -9035, -8521, -8009, -7496, -6982, -6471, -5956, -5444, -4931, -4418, -3904, -3391, -2879, -2366, -1853, -1340, -829, -307};