/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_c604_0014 256 samples */
 
const int16_t AKWF_c604_0014_256_DATA [256] = 
{88, 540, 1069, 1493, 1876, 2384, 3056, 3714, 4160, 4489, 4977, 5658, 6307, 6782, 7158, 7595, 8202, 8900, 9450, 9797, 10190, 10801, 11493, 12054, 12455, 12838, 13373, 14057, 14688, 15113, 15460, 15964, 16639, 17293, 17761, 18104, 18560, 19227, 19889, 20367, 20782, 21242, 21657, 22102, 22747, 23420, 23878, 24336, 25026, 25679, 26071, 26449, 26944, 27387, 27871, 28569, 29197, 29580, 30111, 30887, 31422, 31693, 32160, 32611, 32446, 31904, 31566, 31222, 30516, 29816, 29411, 28934, 28221, 27617, 27188, 26705, 26252, 25909, 25401, 24677, 24094, 23685, 23120, 22418, 21873, 21468, 21024, 20581, 20161, 19595, 18892, 18315, 17943, 17564, 17000, 16308, 15697, 15287, 14936, 14411, 13724, 13095, 12646, 12278, 11812, 11171, 10487, 9980, 9646, 9220, 8573, 7892, 7371, 6982, 6577, 6018, 5323, 4714, 4329, 3977, 3421, 2724, 2120, 1688, 1306, 825, 299, -41, -212, -609, -1335, -1952, -2317, -2876, -3666, -4168, -4402, -4886, -5519, -5847, -6137, -6823, -7563, -7979, -8424, -9136, -9761, -10188, -10677, -11152, -11475, -11950, -12686, -13286, -13683, -14246, -14953, -15487, -15912, -16397, -16803, -17178, -17795, -18504, -18982, -19422, -20088, -20740, -21192, -21630, -22090, -22466, -22948, -23650, -24261, -24676, -25220, -25926, -26479, -26886, -27341, -27768, -28172, -28774, -29474, -29971, -30406, -31053, -31729, -32193, -32535, -32755, -32680, -32381, -32001, -31431, -30724, -30184, -29766, -29157, -28460, -27970, -27579, -27120, -26697, -26250, -25595, -24932, -24488, -24006, -23305, -22690, -22295, -21881, -21414, -20996, -20458, -19753, -19193, -18786, -18188, -17470, -16984, -16630, -16167, -15707, -15265, -14627, -13945, -13498, -13042, -12328, -11686, -11330, -10949, -10433, -9993, -9500, -8785, -8178, -7814, -7249, -6455, -5964, -5734, -5240, -4612, -4290, -3989, -3298, -2567, -2153, -1704, -975, -374, -125};