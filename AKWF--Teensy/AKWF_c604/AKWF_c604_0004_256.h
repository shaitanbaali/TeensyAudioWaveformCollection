/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_c604_0004 256 samples */
 
const int16_t AKWF_c604_0004_256_DATA [256] = 
{6618, 21594, 30605, 32789, 29835, 25148, 21989, 21877, 24172, 26909, 28234, 27529, 25591, 23899, 23554, 24609, 26169, 27110, 26858, 25718, 24570, 24208, 24805, 25856, 26587, 26518, 25768, 24920, 24575, 24932, 25684, 26271, 26295, 25783, 25137, 24822, 25034, 25582, 26056, 26127, 25776, 25283, 25006, 25123, 25521, 25897, 25988, 25755, 25386, 25154, 25210, 25488, 25775, 25868, 25720, 25458, 25277, 25295, 25478, 25680, 25758, 25672, 25504, 25380, 25381, 25487, 25608, 25658, 25615, 25529, 25469, 25470, 25513, 25554, 25562, 25546, 25536, 25545, 25561, 25556, 25518, 25472, 25467, 25523, 25609, 25657, 25615, 25499, 25387, 25376, 25490, 25661, 25757, 25693, 25497, 25305, 25270, 25438, 25700, 25864, 25792, 25515, 25226, 25147, 25359, 25727, 25981, 25917, 25556, 25148, 25001, 25249, 25737, 26112, 26080, 25629, 25069, 24819, 25093, 25729, 26270, 26297, 25746, 24985, 24579, 24867, 25693, 26476, 26612, 25936, 24884, 24223, 24504, 25612, 26789, 27136, 26283, 24733, 23594, 23812, 25425, 27399, 28250, 27087, 24408, 21996, 21863, 24798, 29467, 32699, 31016, 22513, 8174, -8385, -22582, -30883, -32473, -29312, -24829, -22056, -22210, -24486, -26972, -28024, -27229, -25435, -23997, -23821, -24835, -26184, -26907, -26597, -25599, -24682, -24464, -25012, -25855, -26380, -26260, -25654, -25038, -24836, -25142, -25684, -26058, -26026, -25661, -25256, -25098, -25261, -25589, -25832, -25834, -25634, -25404, -25306, -25383, -25544, -25658, -25660, -25580, -25503, -25486, -25514, -25537, -25519, -25488, -25497, -25568, -25652, -25665, -25563, -25402, -25308, -25381, -25601, -25816, -25846, -25630, -25299, -25102, -25218, -25603, -25992, -26078, -25750, -25209, -24850, -24981, -25563, -26201, -26402, -25952, -25118, -24498, -24606, -25458, -26492, -26925, -26329, -25014, -23899, -23894, -25199, -27023, -28018, -27214, -24842, -22421, -21908, -24325, -28729, -32268, -31476, -24108, -10219};