/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_c604_0002 256 samples */
 
const int16_t AKWF_c604_0002_256_DATA [256] = 
{120, 388, 603, 824, 1090, 1435, 1876, 2402, 2993, 3616, 4236, 4834, 5396, 5921, 6424, 6915, 7407, 7908, 8417, 8925, 9430, 9922, 10402, 10876, 11354, 11847, 12366, 12916, 13491, 14082, 14673, 15248, 15796, 16310, 16793, 17260, 17723, 18196, 18690, 19203, 19727, 20256, 20769, 21264, 21738, 22196, 22660, 23141, 23655, 24206, 24788, 25384, 25977, 26547, 27082, 27587, 28072, 28556, 29057, 29579, 30113, 30633, 31097, 31455, 31667, 31706, 31565, 31265, 30842, 30340, 29807, 29278, 28768, 28278, 27796, 27302, 26780, 26225, 25640, 25043, 24453, 23886, 23357, 22864, 22393, 21934, 21470, 20984, 20477, 19955, 19427, 18906, 18405, 17923, 17457, 16995, 16520, 16019, 15487, 14922, 14336, 13742, 13159, 12599, 12067, 11562, 11080, 10606, 10128, 9641, 9140, 8633, 8126, 7623, 7128, 6640, 6140, 5620, 5071, 4485, 3874, 3259, 2664, 2119, 1643, 1238, 896, 590, 284, -52, -441, -890, -1386, -1909, -2438, -2952, -3449, -3934, -4424, -4938, -5486, -6066, -6668, -7269, -7844, -8381, -8873, -9330, -9772, -10219, -10693, -11205, -11754, -12328, -12919, -13509, -14086, -14645, -15178, -15686, -16170, -16634, -17090, -17552, -18038, -18562, -19132, -19736, -20353, -20947, -21478, -21924, -22281, -22573, -22852, -23179, -23604, -24152, -24811, -25526, -26229, -26849, -27342, -27711, -28008, -28313, -28716, -29274, -29991, -30812, -31624, -32292, -32692, -32749, -32456, -31873, -31117, -30316, -29579, -28977, -28515, -28153, -27824, -27457, -27000, -26446, -25812, -25147, -24502, -23911, -23395, -22945, -22535, -22139, -21732, -21298, -20835, -20351, -19849, -19334, -18805, -18253, -17680, -17085, -16472, -15858, -15255, -14672, -14116, -13587, -13076, -12579, -12090, -11604, -11120, -10633, -10140, -9634, -9103, -8543, -7960, -7360, -6764, -6193, -5661, -5175, -4727, -4294, -3851, -3375, -2850, -2284, -1703, -1140, -632, -202};