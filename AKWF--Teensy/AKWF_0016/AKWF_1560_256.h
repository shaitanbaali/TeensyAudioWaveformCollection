/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1560 256 samples */
 
const int16_t AKWF_1560_256_DATA [256] = 
{1206, 2809, 4091, 5156, 6031, 6751, 7350, 7841, 8245, 8576, 8851, 9077, 9262, 9413, 9538, 9641, 9722, 9790, 9845, 9889, 9925, 9952, 9976, 9992, 10006, 10016, 10023, 10028, 10030, 10032, 10032, 10031, 10029, 10027, 10023, 10018, 10015, 10011, 10005, 10000, 9994, 9988, 9982, 9977, 9972, 9966, 9959, 9953, 9947, 9941, 9935, 9928, 9922, 9915, 9909, 9903, 9897, 9890, 9884, 9877, 9871, 9865, 9858, 9852, 9845, 9838, 9832, 9826, 9820, 9814, 9808, 9800, 9794, 9788, 9782, 9775, 9769, 9761, 9756, 9750, 9743, 9738, 9728, 9486, 10642, 5710, -29473, -33484, -32565, -32764, -32761, -32757, -32750, -32741, -32734, -32724, -32713, -32701, -32690, -32678, -32662, -32650, -32635, -32620, -32605, -32589, -32574, -32558, -32310, -33323, -28938, 6056, 10432, 12008, -9554, -26161, -16817, -12685, -8684, -5403, -2684, -446, 1395, 2910, 4170, 5205, 6060, 6766, 7346, 7824, 8219, 8545, 8813, 9033, 9213, 9363, 9484, 9585, 9666, 9731, 9786, 9830, 9863, 9892, 9914, 9931, 9943, 9954, 9962, 9966, 9969, 9971, 9972, 9970, 9968, 9965, 9963, 9957, 9954, 9949, 9944, 9940, 9934, 9927, 9923, 9917, 9911, 9905, 9900, 9894, 9887, 9881, 9876, 9869, 9863, 9856, 9850, 9843, 9837, 9831, 9825, 9819, 9812, 9805, 9799, 9793, 9786, 9781, 9774, 9767, 9761, 9755, 9749, 9743, 9736, 9729, 9723, 9716, 9711, 9704, 9698, 9691, 9685, 9678, 9669, 9348, 11076, 4156, -32072, -32861, -32587, -32686, -32682, -32677, -32669, -32662, -32654, -32644, -32633, -32621, -32610, -32597, -32583, -32571, -32555, -32540, -32525, -32509, -32494, -32475, -31985, -34505, -20916, 11041, 9676, 9868, 9926, 9934, 9940, 9943, 9948, 9949, 9952, 9952, 9952, 9928, 9621, 11684, -14472, -24769, -16073, -12002, -8141, -4984, -2345, -477};