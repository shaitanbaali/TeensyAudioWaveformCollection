/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1534 256 samples */
 
const int16_t AKWF_1534_256_DATA [256] = 
{110, 377, 642, 904, 1167, 1430, 1696, 1959, 2222, 2485, 2747, 3009, 3273, 3533, 3796, 4059, 4319, 4580, 4843, 5105, 5364, 5625, 5887, 6148, 6408, 6667, 6928, 7189, 7447, 7707, 7967, 8224, 8485, 8744, 9002, 9260, 9520, 9780, 10032, 10240, 10494, 10757, 11014, 11269, 11530, 11787, 12047, 12303, 12559, 12819, 13076, 13332, 13588, 13846, 14103, 14358, 14616, 14872, 15127, 15382, 15638, 15894, 16150, 16404, 16660, 16914, 17170, 17426, 17678, 17933, 18186, 18442, 18696, 18951, 19202, 19456, 19710, 19963, 20217, 20470, 20722, 20975, 21226, 21481, 21734, 21983, 22235, 22489, 22741, 22992, 23243, 23493, 23746, 23996, 24247, 24498, 24749, 24998, 25249, 25499, 25750, 25997, 26249, 26498, 26747, 26998, 27245, 27499, 27231, 30160, 20794, -21041, -20684, -20341, -20175, -19918, -19657, -19396, -19135, -18871, -18608, -18342, -18075, -17809, -17541, -17273, -17004, -16736, -16468, -16200, -15928, -15658, -15389, -15117, -14848, -14578, -14307, -14037, -13766, -13496, -13226, -12955, -12685, -12413, -12142, -11873, -11602, -11333, -11061, -10791, -10523, -10252, -9981, -9713, -9444, -9175, -8904, -8636, -8367, -8096, -7828, -7561, -7293, -7023, -6754, -6486, -6218, -5950, -5683, -5415, -5147, -4878, -4612, -4344, -4077, -3807, -3473, -4036, 174, -2770, -22267, -19645, -19809, -19543, -19274, -19003, -18731, -18460, -18193, -17919, -17645, -17376, -17103, -16832, -16560, -16287, -16015, -15743, -15468, -15197, -14928, -14653, -14380, -14110, -13839, -13565, -13292, -13022, -12751, -12479, -12206, -11935, -11663, -11392, -11122, -10853, -10582, -10311, -10040, -9769, -9500, -9230, -8961, -8692, -8420, -8149, -7885, -7614, -7345, -7076, -6807, -6540, -6272, -6002, -5735, -5467, -5198, -4932, -4668, -4398, -4131, -3863, -3598, -3331, -3064, -2799, -2534, -2267, -2002, -1737, -1471, -1206, -940, -678, -413, -143};