/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1566 256 samples */
 
const int16_t AKWF_1566_256_DATA [256] = 
{49, 293, 591, 819, 1010, 1211, 1432, 1683, 1944, 2192, 2411, 2603, 2786, 2972, 3164, 3364, 3565, 3751, 3920, 4078, 4226, 4377, 4524, 4675, 4828, 4964, 5093, 5211, 5326, 5448, 5569, 5677, 5782, 5885, 5976, 6063, 6152, 6234, 6311, 6387, 6457, 6521, 6584, 6643, 6696, 6748, 6798, 6845, 6881, 6916, 6956, 6988, 7011, 7036, 7057, 7075, 7087, 7101, 7109, 7109, 7111, 7115, 7108, 7100, 7098, 7089, 7078, 7061, 7045, 7025, 7005, 6981, 6954, 6925, 6896, 6864, 6827, 6788, 6748, 6705, 6664, 6619, 6570, 6525, 6474, 6422, 6365, 6311, 6254, 6196, 6136, 6075, 6009, 5950, 5880, 5816, 5744, 5671, 5599, 5526, 5458, 5381, 5300, 5221, 5144, 5069, 4987, 4905, 4818, 4736, 4656, 4565, 4480, 4395, 4304, 4214, 4123, 4032, 3940, 3848, 3753, 3661, 3564, 3471, 3375, 3275, 3178, 3082, 2980, 2887, 2786, 2684, 2586, 2480, 2378, 2280, 2173, 2073, 1973, 1864, 1756, 1654, 1547, 1441, 1333, 1226, 1118, 1013, 904, 796, 686, 580, 470, 359, 248, 139, 30, -77, -184, -297, -411, -520, -634, -739, -852, -969, -1080, -1190, -1306, -1415, -1528, -1639, -1749, -1862, -1973, -2085, -2192, -2304, -2419, -2533, -2644, -2755, -2863, -2979, -3091, -3198, -3314, -3426, -3536, -3644, -3758, -3866, -3980, -4089, -4199, -4304, -4689, -3416, -10668, -29217, -30063, -30568, -31098, -31496, -31829, -32095, -32297, -32435, -32540, -32580, -32582, -32349, -33203, -28244, -11350, -9471, -6928, -2999, 527, 2098, 1224, -1227, -3745, -5030, -4792, -3669, -2699, -2614, -3451, -4669, -5567, -5739, -5255, -4552, -4100, -4091, -4427, -4785, -4876, -4603, -4099, -3594, -3261, -3140, -3129, -3060, -2844, -2481, -2050, -1668, -1392, -1207, -1048, -844, -565, -232};