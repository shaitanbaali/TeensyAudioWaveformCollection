/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1554 256 samples */
 
const int16_t AKWF_1554_256_DATA [256] = 
{528, 1416, 2122, 2710, 3195, 3597, 3929, 4199, 4423, 4608, 4761, 4885, 4988, 5072, 5140, 5196, 5242, 5280, 5310, 5334, 5354, 5370, 5381, 5390, 5398, 5402, 5407, 5409, 5411, 5410, 5410, 5409, 5407, 5406, 5403, 5401, 5399, 5396, 5393, 5390, 5387, 5382, 5378, 5375, 5372, 5369, 5365, 5360, 5357, 5353, 5350, 5346, 5342, 5338, 5334, 5330, 5326, 5323, 5318, 5314, 5310, 5306, 5304, 5299, 5295, 5291, 5287, 5283, 5280, 5276, 5272, 5139, 5701, 3515, -24086, -23725, -17566, -13786, -10478, -7712, -5442, -3568, -2022, -747, 303, 1173, 1887, 2482, 2967, 3369, 3701, 3974, 4200, 4384, 4535, 4663, 4765, 4849, 4919, 4975, 5022, 5058, 5089, 5114, 5134, 5149, 5162, 5171, 5178, 5184, 5188, 5190, 5190, 5192, 5191, 5190, 5189, 5189, 5187, 5184, 5182, 5178, 5175, 5171, 5168, 5166, 5163, 5159, 5155, 5151, 5147, 5144, 5141, 5138, 5133, 5129, 5126, 5122, 5118, 5116, 5111, 5106, 5103, 5099, 5095, 5093, 5089, 5084, 5080, 5076, 5073, 5070, 5065, 5062, 5058, 5053, 5049, 5047, 5043, 5038, 5035, 5032, 5027, 5024, 5017, 4491, 7373, -6797, -35083, -32229, -32759, -32760, -32755, -32747, -32740, -32730, -32720, -32711, -32699, -32686, -32673, -32661, -32646, -32631, -32617, -32602, -32587, -32571, -32555, -32539, -32094, -34480, -22454, 7270, 4859, 5313, 5310, 5319, 5327, 5331, 5337, 5342, 5346, 5348, 5351, 5352, 5354, 5353, 5353, 5354, 5352, 5352, 5350, 5348, 5347, 5346, 5344, 5342, 5338, 5337, 5333, 5329, 5328, 5325, 5322, 5318, 5316, 5312, 5307, 5305, 5303, 5299, 5296, 5291, 5287, 5284, 5281, 5277, 5274, 5269, 5264, 5262, 5257, 5115, 5744, 3486, -23963, -23976, -17748, -13943, -10583, -7827, -5536, -3649, -2072, -519};