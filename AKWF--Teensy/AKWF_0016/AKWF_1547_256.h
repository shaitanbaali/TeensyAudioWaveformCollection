/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1547 256 samples */
 
const int16_t AKWF_1547_256_DATA [256] = 
{402, 1334, 2033, 2621, 3103, 3501, 3831, 4103, 4326, 4510, 4662, 4787, 4889, 4974, 5042, 5099, 5144, 5183, 5213, 5238, 5258, 5273, 5286, 5295, 5303, 5309, 5313, 5316, 5318, 5131, 6035, 2438, -24895, -23229, -17358, -13582, -10263, -7540, -5289, -3430, -1889, -619, 419, 1280, 1995, 2582, 3065, 3466, 3793, 4064, 4288, 4474, 4626, 4751, 4852, 4937, 5006, 5063, 5109, 5145, 5177, 5202, 5222, 5237, 5250, 5259, 5267, 5273, 5277, 5280, 5283, 5283, 5283, 5281, 5281, 5279, 5278, 5276, 5274, 5272, 5270, 5267, 5263, 5261, 5258, 5255, 5252, 5248, 5246, 5242, 5238, 5236, 5233, 5229, 5226, 5223, 5219, 5215, 5213, 5208, 5205, 5203, 5200, 5196, 5192, 5189, 5185, 5182, 5179, 5175, 5171, 5168, 5166, 5161, 5157, 5154, 5150, 5147, 5144, 5140, 5137, 5133, 5138, 4444, 8040, -11148, -35273, -32206, -32752, -32757, -32753, -32746, -32737, -32728, -32717, -32707, -32694, -32681, -32668, -32654, -32640, -32626, -32610, -32595, -32579, -32563, -32546, -32523, -31923, -35087, -17989, 8105, 4792, 5422, 5436, 5444, 5452, 5459, 5464, 5468, 5472, 5476, 5479, 5480, 5481, 5483, 5482, 5482, 5484, 5482, 5482, 5480, 5478, 5478, 5476, 5474, 5472, 5469, 5466, 5465, 5463, 5460, 5457, 5454, 5451, 5448, 5446, 5443, 5439, 5436, 5433, 5429, 5427, 5424, 5421, 5417, 5414, 5411, 5407, 5403, 5401, 5397, 5393, 5390, 5387, 5382, 5379, 5376, 5372, 5368, 5365, 5363, 5359, 5355, 5352, 5347, 5344, 5342, 5338, 5334, 5331, 5328, 5324, 5321, 5317, 5313, 5310, 5307, 5303, 5300, 5297, 5293, 5289, 5286, 5283, 5279, 5276, 5273, 5270, 5266, 5262, 5259, 5205, 5023, 6558, -22965, -31282, -22182, -17881, -13849, -10490, -7728, -5458, -3583, -2038, -745};