/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1572 256 samples */
 
const int16_t AKWF_1572_256_DATA [256] = 
{13005, 32801, 32243, 32015, 31873, 31667, 31473, 31269, 31072, 30876, 30680, 30488, 30291, 30101, 29912, 29721, 29537, 29352, 29163, 28982, 28800, 28618, 28439, 28260, 28085, 27912, 27735, 27563, 27390, 27220, 27052, 26883, 26718, 26555, 26388, 26227, 26066, 25903, 25748, 25586, 25431, 25280, 25124, 24975, 24822, 24671, 24527, 24376, 24237, 24085, 23699, 24863, 13134, -10114, -11377, -10584, -10466, -10469, 13513, 31170, 29226, 29288, 29111, 28908, 28705, 28512, 28314, 28115, 27928, 27725, 27175, 29016, 19480, -4446, -2771, -3281, -3472, -3659, -3820, -4002, -4172, -4343, -4502, -4671, -4836, -4997, -5157, -5315, -5476, -5629, -5785, -5937, -6087, -6238, -6386, -6530, -6677, -6820, -6966, -7105, -7245, -7385, -7522, -7656, -7792, -7926, -8059, -8191, -8318, -8446, -8571, -8700, -8823, -8947, -9068, -9188, -9308, -9429, -9543, -9660, -9777, -9887, -10002, -10114, -10223, -10334, -10442, -10550, -10658, -10761, -10866, -10970, -11074, -11175, -11274, -11373, -11473, -11568, -11666, -11762, -11857, -11949, -12042, -12137, -12223, -12314, -12402, -12491, -12577, -12665, -12750, -12835, -12916, -13001, -13081, -13161, -13244, -13323, -13400, -13481, -13557, -13634, -13710, -13783, -13859, -13931, -14004, -14077, -14148, -14228, -13746, -16744, 1380, 17715, 14828, 15294, 15221, 15105, 14905, 15848, -3972, -25470, -24122, -23784, -23456, -23065, -22672, -22294, -21908, -21533, -21160, -20788, -20422, -20058, -19695, -19337, -18982, -18629, -18281, -17933, -17593, -17254, -16916, -16585, -16250, -15924, -15601, -15275, -14958, -14639, -14323, -14014, -13703, -13398, -13096, -12794, -12498, -12201, -11907, -11618, -11328, -11045, -10762, -10480, -10203, -9928, -9657, -9389, -9121, -8856, -8593, -8334, -8077, -7821, -7568, -7320, -7069, -6825, -6584, -6341, -6100, -5863, -5630, -5400, -5165, -4938, -4710, -4483, -4264, -4044, -3822, -3608, -3388, -3168, -2942, -2460};