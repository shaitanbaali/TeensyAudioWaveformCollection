/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1530 256 samples */
 
const int16_t AKWF_1530_256_DATA [256] = 
{72, 320, 563, 807, 1048, 1292, 1534, 1776, 2020, 2261, 2504, 2749, 2986, 3213, 3457, 3700, 3940, 4180, 4424, 4665, 4906, 5148, 5387, 5629, 5870, 6112, 6353, 6592, 6832, 7074, 7312, 7551, 7793, 8031, 8271, 8510, 8751, 8990, 9227, 9466, 9705, 9943, 10183, 10421, 10659, 10897, 11134, 11371, 11609, 11848, 12083, 12320, 12558, 12796, 13031, 13268, 13505, 13741, 13977, 14213, 14449, 14683, 14920, 15156, 15392, 15626, 15861, 16097, 16331, 16566, 16802, 17036, 17270, 17503, 17738, 17973, 18206, 18438, 18672, 18907, 19138, 19372, 19603, 19838, 20069, 20302, 20535, 20768, 20998, 21231, 21465, 21696, 21927, 22158, 22391, 22622, 22852, 23084, 23314, 23544, 23774, 24006, 24237, 24467, 24697, 24927, 25156, 25384, 25616, 25847, 26073, 26303, 26532, 26762, 26990, 27217, 27445, 27675, 27903, 28130, 28359, 28586, 28814, 29041, 29268, 29437, 29333, 32039, -11585, -30269, -26448, -26877, -26643, -26403, -26162, -25919, -25676, -25429, -25184, -24935, -24687, -24438, -24191, -23655, -25199, -15962, -19836, -28819, -26764, -26794, -26540, -26286, -26031, -25778, -25523, -25267, -25012, -24757, -24500, -24247, -23989, -23734, -23476, -23222, -22968, -22710, -22456, -22200, -21943, -21688, -21433, -21179, -20922, -20666, -20413, -20155, -19902, -19646, -19392, -19136, -18881, -18627, -18374, -18119, -17865, -17611, -17356, -17101, -16848, -16594, -16340, -16086, -15830, -15580, -15325, -15071, -14820, -14568, -14315, -14064, -13809, -13557, -13306, -13054, -12802, -12551, -12299, -12047, -11797, -11545, -11294, -11043, -10793, -10544, -10293, -10042, -9792, -9543, -9294, -9044, -8796, -8546, -8297, -8049, -7800, -7550, -7303, -7054, -6807, -6560, -6311, -6064, -5816, -5568, -5321, -5073, -4828, -4580, -4333, -4088, -3842, -3596, -3349, -3103, -2859, -2615, -2368, -2123, -1877, -1631, -1388, -1143, -898, -654, -411, -163};