/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1521 256 samples */
 
const int16_t AKWF_1521_256_DATA [256] = 
{1773, 5636, 9640, 15125, 17809, 18766, 19993, 21099, 22148, 23141, 24079, 24965, 25800, 26584, 27321, 28008, 28648, 29243, 29789, 30289, 30745, 31153, 31515, 31832, 32103, 32328, 32507, 32639, 32713, 32815, 32524, 31098, 30199, 29476, 28833, 28246, 27702, 27189, 26701, 26234, 25786, 25351, 24930, 24520, 24121, 23732, 23349, 22974, 22608, 22246, 21888, 21539, 21194, 20853, 20515, 20183, 19855, 19530, 19207, 18889, 18573, 18258, 17947, 17639, 17333, 17030, 16726, 16427, 16130, 15833, 15539, 15245, 14955, 14665, 14377, 14088, 13802, 13518, 13236, 12954, 12673, 12393, 12113, 11837, 11558, 11282, 11007, 10732, 10458, 10187, 9913, 9641, 9370, 9099, 8831, 8561, 8292, 8025, 7756, 7490, 7222, 6956, 6690, 6425, 6160, 5896, 5632, 5367, 5104, 4841, 4578, 4315, 4052, 3789, 3528, 3266, 3003, 2741, 2480, 2218, 1956, 1696, 1433, 1174, 912, 652, 390, 129, -130, -391, -653, -913, -1175, -1434, -1697, -1957, -2219, -2481, -2742, -3004, -3267, -3529, -3790, -4053, -4316, -4579, -4842, -5104, -5368, -5633, -5897, -6161, -6426, -6691, -6957, -7223, -7491, -7757, -8026, -8293, -8562, -8832, -9100, -9371, -9642, -9914, -10187, -10459, -10732, -11008, -11283, -11559, -11838, -12113, -12393, -12674, -12954, -13237, -13519, -13803, -14089, -14378, -14665, -14956, -15246, -15539, -15834, -16131, -16427, -16727, -17030, -17333, -17639, -17948, -18259, -18573, -18889, -19207, -19530, -19855, -20184, -20515, -20854, -21195, -21539, -21889, -22246, -22608, -22974, -23349, -23733, -24121, -24520, -24930, -25351, -25786, -26234, -26701, -27190, -27702, -28247, -28833, -29476, -30199, -31098, -32524, -32815, -32713, -32639, -32507, -32328, -32103, -31832, -31515, -31153, -30745, -30289, -29789, -29243, -28648, -28008, -27321, -26585, -25800, -24965, -24079, -23142, -22148, -21099, -19993, -18766, -17809, -15126, -9641, -5637, -1773};