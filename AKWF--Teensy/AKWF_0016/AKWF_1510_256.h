/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1510 256 samples */
 
const int16_t AKWF_1510_256_DATA [256] = 
{6553, 6553, 6552, 6552, 6552, 6647, 6128, 8636, 13640, 12573, 15275, 20111, 19559, 19767, 19183, 23873, 26669, 26111, 26213, 26213, 26213, 26213, 26213, 26213, 26213, 26213, 26213, 26213, 26213, 26213, 26214, 26214, 26213, 26272, 25945, 27351, 32914, 32742, 32727, 32910, 32220, 26436, 26146, 26134, 26659, 23959, 19195, 19764, 19587, 19997, 18145, 12811, 13168, 13107, 13027, 13470, 11435, 6209, 6627, 6553, 6553, 6553, 6553, 6544, 6545, 6630, 996, -241, 52, 0, -1, 0, -1, -1, -67, 309, -1360, -6794, -6505, -6551, -6553, -6553, -6553, -6553, -6554, -6553, -6553, -6553, -6553, -6554, -6553, -6553, -6553, -6553, -6553, -6554, -6553, -6553, -6553, -6553, -6554, -6554, -6553, -6553, -6554, -6553, -6553, -6567, -6521, -6530, -12852, -9079, -6055, -6656, -6554, -6553, -6554, -6553, -6554, -6553, -6553, -6553, -6442, -7044, -3861, 509, -117, 0, 115, -505, 2870, 7071, 6434, 6552, 6552, 6552, 6553, 6553, 6553, 6553, 6553, 6622, 6213, 8032, 13246, 7165, 6380, 6592, 6552, 6553, 6553, 6553, 6552, 6553, 6553, 6553, 6552, 6553, 6552, 6553, 6553, 6553, 6553, 6552, 6552, 6553, 6553, 6552, 6553, 6552, 6553, 6553, 6552, 6552, 6552, 6553, 6448, 7017, 2254, -446, 99, 0, 0, -1, 0, -1, -25, 91, -325, -6121, -6670, -6524, -6553, -6554, -6553, -6553, -6668, -6051, -10503, -13590, -12998, -13107, -13216, -12620, -17231, -20125, -19555, -19780, -19138, -22982, -26734, -26097, -26255, -26002, -31482, -33062, -32703, -32673, -33188, -28213, -25801, -26305, -26213, -26214, -26214, -26213, -26213, -26214, -26213, -26213, -26214, -26213, -26213, -26214, -26213, -26213, -26213, -26144, -26537, -24778, -19391, -19715, -19542, -20183, -16248, -12469, -13748, -9604, -6039, -6672, -6553, -6553, -6547, -6537, -6667, -1067};