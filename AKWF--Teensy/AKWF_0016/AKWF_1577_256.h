/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1577 256 samples */
 
const int16_t AKWF_1577_256_DATA [256] = 
{4463, 5004, 4698, 4595, 4455, 4324, 4186, 4055, 3926, 3968, 2968, 8979, 23339, 24313, 23568, 23303, 22939, 22570, 22213, 21856, 21498, 21148, 20800, 20454, 20111, 19769, 19433, 19098, 18765, 18436, 18109, 17790, 17625, 16481, 19613, 32616, 32040, 31720, 31441, 31142, 30843, 30542, 30249, 29955, 29664, 29378, 29090, 28809, 28524, 28118, 28539, 21235, 9252, 8820, 8930, 8817, 8766, 8719, 8668, 8620, 8573, 8525, 8480, 8433, 8388, 8344, 8299, 8255, 8211, 8169, 8127, 8085, 8042, 8002, 7961, 7919, 7880, 7840, 7803, 7764, 7724, 7688, 7649, 7612, 7575, 7539, 7503, 7468, 7432, 7397, 7364, 7331, 7296, 7263, 7231, 7199, 7166, 7134, 7103, 7072, 7041, 7012, 6981, 6950, 6921, 6892, 6863, 6835, 6806, 6776, 6748, 6722, 6693, 6667, 6640, 6613, 6586, 6560, 6536, 6510, 6484, 6460, 6435, 6411, 6387, 6363, 6341, 6319, 6294, 6276, 6230, 6126, 6682, -3549, -15183, -14501, -14292, -14107, -13885, -13665, -13450, -13231, -13016, -12805, -12594, -12387, -12179, -11974, -11770, -11566, -11367, -11169, -10972, -10776, -10583, -10391, -10202, -10013, -9826, -9642, -9457, -9276, -9094, -8916, -8738, -8562, -8389, -8216, -8045, -7873, -7707, -7537, -7372, -7207, -7047, -6885, -6724, -6569, -6411, -6258, -6100, -5952, -5800, -5654, -5498, -5356, -5206, -5297, -3898, -9792, -21461, -20139, -20213, -20067, -19933, -19800, -19663, -19529, -19397, -19265, -19135, -19005, -18877, -18748, -18623, -18499, -18374, -18250, -18128, -18006, -17886, -17767, -17651, -17532, -17417, -17302, -17188, -17075, -16963, -16854, -16743, -16634, -16527, -16419, -16313, -16209, -16104, -16003, -15901, -15798, -15700, -15600, -15503, -15405, -15309, -15211, -15118, -15024, -14931, -14839, -14747, -14657, -14566, -14478, -14389, -14301, -14216, -14130, -14045, -13963, -13878, -13796, -13707, -13517, -14058, -7105};