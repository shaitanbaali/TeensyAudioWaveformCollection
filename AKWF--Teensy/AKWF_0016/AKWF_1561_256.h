/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1561 256 samples */
 
const int16_t AKWF_1561_256_DATA [256] = 
{336, 1256, 2102, 2852, 3548, 4179, 4742, 5268, 5734, 6163, 6557, 6906, 7232, 7521, 7791, 8035, 8249, 8449, 8631, 8795, 8946, 9079, 9204, 9314, 9413, 9506, 9589, 9664, 9731, 9792, 9849, 9897, 9943, 9983, 10019, 10053, 10080, 10108, 10132, 10152, 10171, 10187, 10202, 10214, 10226, 10238, 10246, 10253, 10258, 10264, 10268, 10271, 10275, 10277, 10277, 10279, 10279, 10279, 10279, 10277, 10276, 10276, 10272, 10270, 10269, 10266, 10264, 10259, 10256, 10254, 10251, 10247, 10242, 10238, 10235, 10231, 10227, 10222, 10218, 10214, 10209, 10206, 10202, 10197, 10193, 10187, 10183, 10180, 10175, 10169, 10164, 10160, 10157, 10152, 10145, 10142, 10137, 10132, 10127, 10123, 10119, 10113, 10109, 10104, 10099, 10095, 10089, 10085, 10081, 10075, 10069, 10066, 10061, 10057, 10052, 10046, 10042, 10037, 10030, 10028, 10022, 10017, 10012, 10007, 10002, 9999, 9992, 9987, 9984, 9978, 9974, 9969, 9964, 9960, 9955, 9950, 9947, 9940, 9936, 9931, 9925, 9920, 9916, 9912, 9908, 9902, 9896, 9893, 9888, 9882, 9879, 9873, 9869, 9865, 9859, 9854, 9850, 9844, 9839, 9835, 9830, 9826, 9821, 9815, 9812, 9806, 9802, 9798, 9791, 9788, 9783, 9773, 9841, 8865, 13498, -7399, -35121, -32060, -32792, -32761, -32765, -32763, -32758, -32755, -32751, -32745, -32741, -32733, -32726, -32718, -32710, -32703, -32692, -32685, -32676, -32666, -32656, -32646, -32635, -32624, -32614, -32602, -32592, -32581, -32569, -32557, -32546, -32535, -32522, -32511, -32498, -32486, -32474, -32461, -32449, -32436, -32425, -32411, -32398, -32385, -32374, -32360, -32342, -32353, -31648, -34654, -9355, 13991, 9311, 10294, 10229, 10241, 10248, 10252, 10256, 10260, 10262, 10263, 10227, 10036, 11562, -4774, -28230, -23930, -20710, -18058, -15479, -13132, -11029, -9075, -7348, -5727, -4283, -2981, -1773, -635};