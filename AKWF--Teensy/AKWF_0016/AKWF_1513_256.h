/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1513 256 samples */
 
const int16_t AKWF_1513_256_DATA [256] = 
{1051, 3247, 5382, 7501, 9584, 11628, 13623, 15551, 17415, 19204, 20903, 22514, 24027, 25432, 26729, 27911, 28969, 29905, 30712, 31387, 31931, 32339, 32612, 32750, 32752, 32623, 32359, 31966, 31449, 30808, 30050, 29179, 28200, 27121, 25948, 24686, 23347, 21934, 20458, 18929, 17354, 15742, 14107, 12454, 10793, 9142, 7501, 5887, 4313, 2782, 1311, -86, -1404, -2626, -3739, -4734, -5593, -6301, -6814, -7293, -6555, -2459, 1888, 5748, 9402, 12887, 16406, 19545, 20357, 20198, 19868, 19278, 18471, 17473, 16307, 14989, 13535, 11971, 10305, 8553, 6736, 4859, 2939, 994, -972, -2942, -4900, -6845, -8759, -10628, -12450, -14210, -15896, -17507, -19027, -20449, -21771, -22978, -24069, -25039, -25878, -26585, -27158, -27591, -27883, -28032, -28038, -27900, -27619, -27198, -26637, -25939, -25111, -24152, -23069, -21872, -20558, -19141, -17628, -16022, -14336, -12578, -10751, -8872, -6950, -4988, -3003, -1005, 1004, 3002, 4987, 6949, 8872, 10750, 12577, 14335, 16021, 17628, 19140, 20558, 21872, 23069, 24152, 25111, 25939, 26637, 27198, 27619, 27900, 28038, 28032, 27883, 27591, 27158, 26585, 25878, 25039, 24069, 22978, 21770, 20449, 19027, 17507, 15896, 14209, 12450, 10627, 8758, 6845, 4899, 2941, 971, -995, -2940, -4859, -6737, -8553, -10306, -11972, -13535, -14989, -16308, -17474, -18472, -19278, -19868, -20199, -20358, -19546, -16406, -12887, -9403, -5749, -1889, 2458, 6555, 7292, 6813, 6300, 5592, 4733, 3738, 2625, 1403, 85, -1312, -2783, -4314, -5888, -7502, -9142, -10794, -12454, -14108, -15742, -17354, -18930, -20458, -21934, -23347, -24686, -25948, -27121, -28200, -29179, -30050, -30808, -31449, -31966, -32359, -32623, -32752, -32750, -32612, -32339, -31931, -31387, -30712, -29905, -28969, -27911, -26729, -25432, -24027, -22514, -20904, -19205, -17415, -15552, -13623, -11628, -9585, -7502, -5383, -3248, -1052};