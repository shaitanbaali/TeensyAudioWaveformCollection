/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1533 256 samples */
 
const int16_t AKWF_1533_256_DATA [256] = 
{157, 454, 745, 1039, 1333, 1628, 1919, 2212, 2504, 2799, 3090, 3382, 3675, 3968, 4256, 4550, 4842, 5131, 5421, 5713, 6006, 6296, 6586, 6875, 7166, 7454, 7745, 8036, 8325, 8613, 8904, 9193, 9481, 9770, 10056, 10347, 10635, 10921, 11209, 11504, 11740, 11985, 12281, 12567, 12854, 13136, 13426, 13713, 13999, 14284, 14568, 14855, 15142, 15428, 15712, 15996, 16282, 16566, 16850, 17137, 17420, 17701, 17986, 18271, 18556, 18840, 19120, 19404, 19687, 19970, 20254, 20537, 20816, 21100, 21381, 21666, 21946, 22225, 22508, 22791, 23069, 23351, 23632, 23912, 24192, 24471, 24754, 25034, 25312, 25591, 25872, 26150, 26429, 26709, 26987, 27264, 27544, 27823, 28100, 28378, 28656, 28934, 29211, 29487, 29764, 30044, 30320, 30594, 30874, 31148, 31265, 32184, 30820, -17987, -24881, -22957, -22980, -22696, -22410, -22117, -21827, -21535, -21241, -20945, -20649, -20355, -20060, -19760, -19462, -19162, -18862, -18563, -18265, -17966, -17665, -17363, -17063, -16764, -16462, -16159, -15859, -15558, -15255, -14955, -14657, -14353, -14051, -13751, -13453, -13150, -12850, -12548, -12251, -11951, -11649, -11349, -11050, -10748, -10448, -10150, -9852, -9551, -9250, -8954, -8656, -8356, -8058, -7758, -7461, -7163, -6866, -6569, -6270, -5973, -5623, -6341, -1064, -3827, -25901, -22247, -22581, -22287, -21989, -21688, -21385, -21085, -20785, -20483, -20181, -19880, -19577, -19276, -18972, -18671, -18370, -18064, -17762, -17462, -17161, -16856, -16552, -16252, -15951, -15647, -15345, -15043, -14742, -14440, -14137, -13835, -13534, -13233, -12932, -12632, -12332, -12029, -11728, -11429, -11129, -10828, -10529, -10230, -9929, -9630, -9331, -9033, -8731, -8431, -8135, -7838, -7537, -7240, -6941, -6643, -6346, -6049, -5753, -5456, -5156, -4858, -4565, -4268, -3970, -3673, -3378, -3083, -2787, -2490, -2195, -1900, -1603, -1310, -1017, -723, -427, -130};