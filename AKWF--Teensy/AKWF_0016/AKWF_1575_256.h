/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1575 256 samples */
 
const int16_t AKWF_1575_256_DATA [256] = 
{326, 756, 1140, 1524, 1901, 2280, 2652, 3001, 3342, 3667, 3983, 4292, 4597, 4885, 5169, 5428, 5696, 5953, 6196, 6435, 6661, 6881, 7106, 7320, 7506, 7700, 7881, 8055, 8224, 8387, 8539, 8674, 8812, 8939, 9062, 9181, 9289, 9389, 9488, 9581, 9663, 9732, 9806, 9884, 9939, 9988, 10039, 10079, 10117, 10145, 10174, 10196, 10198, 10209, 10219, 10207, 10205, 10205, 10196, 10181, 10152, 10127, 10099, 10069, 10027, 9984, 9936, 9889, 9835, 9777, 9711, 9642, 9575, 9505, 9427, 9346, 9265, 9184, 9093, 8996, 8906, 8810, 8708, 8611, 8504, 8393, 8289, 8168, 8060, 7936, 7814, 7687, 7562, 7445, 7310, 7172, 7037, 6908, 6774, 6630, 6491, 6339, 6199, 6058, 5903, 5756, 5605, 5450, 5296, 5135, 4977, 4816, 4659, 4494, 4333, 4165, 4004, 3835, 3663, 3494, 3325, 3149, 2987, 2811, 2637, 2464, 2281, 2103, 1930, 1744, 1570, 1393, 1204, 1017, 840, 656, 469, 278, 93, -97, -275, -465, -656, -848, -1033, -1222, -1417, -1611, -1802, -1992, -2183, -2373, -2568, -2765, -2959, -3155, -3342, -3536, -3742, -3939, -4131, -4329, -4521, -4721, -4914, -5103, -5302, -5497, -5693, -5880, -6079, -6279, -6477, -6671, -6866, -7058, -7258, -7455, -7640, -7843, -8041, -8234, -8416, -8624, -8808, -9006, -8975, -10111, -6742, 23663, 32475, 24047, -3304, 456, 2853, 491, -4831, -10671, -14517, -15488, -14505, -13401, -13640, -15546, -18273, -20607, -21663, -21415, -20557, -19909, -20026, -20793, -21683, -22143, -21930, -21198, -20342, -19736, -19495, -19476, -19406, -19055, -18408, -17598, -16816, -16196, -15748, -15370, -14911, -14315, -13607, -12872, -12194, -11609, -11096, -10590, -10030, -9422, -8774, -8142, -7568, -7033, -6521, -6012, -5478, -4931, -4389, -3864, -3374, -2904, -2434, -1973, -1514, -1056, -594, -157};