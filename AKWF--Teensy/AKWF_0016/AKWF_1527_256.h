/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1527 256 samples */
 
const int16_t AKWF_1527_256_DATA [256] = 
{2398, 8951, 14435, 19063, 22844, 25841, 28114, 29704, 30708, 31163, 31072, 30655, 30058, 29215, 28097, 26791, 25353, 23810, 22241, 20635, 19005, 17418, 15858, 14333, 12859, 11448, 10106, 8834, 7641, 6508, 5477, 4524, 3610, 2794, 2044, 1347, 723, 155, -358, -826, -1208, -1557, -1866, -2124, -2351, -2537, -2669, -2771, -2820, -2857, -2854, -2830, -2783, -2674, -2517, -2358, -2176, -1931, -1646, -1332, -969, -537, -44, 490, 1102, 1782, 2508, 3273, 4137, 5123, 6182, 7289, 8480, 9733, 10995, 12167, 13220, 14091, 14656, 14742, 14155, 12657, 10020, 6028, 380, -7040, -16550, -26176, -31314, -32690, -32639, -32165, -31588, -30993, -30406, -29829, -29261, -28704, -28158, -27622, -27080, -26532, -26041, -20100, -3635, 15061, 25414, 28717, 29271, 28995, 28510, 27981, 27452, 26930, 26418, 25917, 25424, 24940, 24466, 24001, 23544, 23097, 22644, 22227, 21663, 18540, 12148, 4667, -2510, -8916, -14422, -19064, -22845, -25843, -28115, -29704, -30708, -31163, -31072, -30655, -30059, -29215, -28096, -26791, -25353, -23807, -22238, -20635, -19006, -17418, -15858, -14333, -12860, -11449, -10107, -8835, -7642, -6509, -5477, -4523, -3611, -2794, -2048, -1351, -723, -153, 357, 825, 1207, 1556, 1865, 2123, 2350, 2536, 2668, 2770, 2818, 2856, 2853, 2829, 2782, 2673, 2516, 2357, 2173, 1930, 1645, 1331, 969, 538, 46, -489, -1103, -1786, -2510, -3274, -4137, -5124, -6183, -7290, -8480, -9733, -10996, -12169, -13221, -14092, -14656, -14743, -14157, -12658, -10021, -6026, -381, 7039, 16549, 26174, 31313, 32688, 32638, 32163, 31587, 30993, 30404, 29827, 29261, 28704, 28158, 27622, 27080, 26532, 26041, 20101, 3634, -15061, -25414, -28717, -29271, -28995, -28510, -27981, -27453, -26932, -26419, -25918, -25424, -24940, -24468, -24001, -23545, -23098, -22646, -22228, -21663, -18553, -12177, -4575};