/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1600 256 samples */
 
const int16_t AKWF_1600_256_DATA [256] = 
{4837, 14494, 22368, 27814, 30691, 31522, 31417, 31100, 30589, 29785, 28514, 26800, 25000, 23515, 22715, 22632, 23080, 23772, 24111, 23571, 22039, 19685, 17242, 15093, 13252, 11565, 9591, 7393, 5677, 5223, 6701, 9954, 14168, 18238, 21015, 21894, 21131, 19289, 17219, 15092, 12693, 10009, 7014, 4053, 1835, 528, 69, 72, 163, 187, -226, -1458, -3567, -6371, -9151, -11542, -13538, -15124, -16456, -17173, -16288, -13080, -7214, 686, 9362, 17602, 24406, 29098, 31657, 32550, 32753, 32603, 32048, 31054, 29321, 27079, 25094, 23824, 23518, 23950, 24677, 25168, 24814, 23432, 21471, 19308, 17179, 15042, 12688, 10038, 7064, 4305, 2726, 2845, 4730, 7820, 11374, 14716, 17154, 18183, 17736, 16180, 14320, 12495, 10757, 8982, 6638, 3709, 872, -1108, -1529, -652, 651, 1528, 1108, -871, -3709, -6636, -8978, -10750, -12487, -14306, -16168, -17474, -17167, -14647, -9847, -3462, 3461, 9846, 14647, 17167, 17473, 16167, 14306, 12487, 10749, 8977, 6635, 3708, 870, -1109, -1529, -652, 651, 1528, 1107, -873, -3710, -6639, -8983, -10757, -12496, -14321, -16180, -17736, -18184, -17154, -14717, -11375, -7820, -4731, -2846, -2727, -4306, -7064, -10038, -12688, -15043, -17179, -19308, -21472, -23433, -24814, -25169, -24677, -23950, -23518, -23824, -25094, -27079, -29321, -31054, -32048, -32603, -32753, -32550, -31657, -29098, -24406, -17603, -9363, -687, 7213, 13079, 16287, 17173, 16456, 15123, 13537, 11541, 9151, 6371, 3566, 1457, 225, -188, -164, -73, -70, -529, -1836, -4054, -7015, -10010, -12694, -15092, -17219, -19289, -21131, -21894, -21015, -18238, -14168, -9955, -6701, -5224, -5678, -7394, -9592, -11565, -13252, -15093, -17243, -19686, -22040, -23572, -24112, -23772, -23080, -22632, -22715, -23515, -25000, -26801, -28514, -29785, -30589, -31100, -31417, -31522, -30691, -27814, -22368, -14494, -4838};