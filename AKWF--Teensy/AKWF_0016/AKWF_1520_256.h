/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1520 256 samples */
 
const int16_t AKWF_1520_256_DATA [256] = 
{4077, 5554, 6999, 8449, 9899, 11350, 12804, 14251, 15703, 17157, 18606, 20057, 21510, 22957, 24409, 25863, 27310, 28760, 30181, 31760, 32439, 31007, 29579, 28157, 26729, 25303, 23872, 22440, 21013, 19579, 18148, 16717, 15281, 13849, 12416, 10978, 9545, 8110, 6672, 5239, 3803, 2376, 886, 323, 399, 383, 383, 383, 383, 382, 383, 381, 379, 380, 380, 380, 380, 380, 380, 379, 388, 361, 500, 1754, 3194, 4590, 5995, 7403, 8805, 10210, 11616, 13017, 14421, 15826, 17226, 18628, 20032, 21431, 22833, 24233, 25629, 27028, 28427, 29789, 31335, 31629, 30106, 28708, 27293, 25877, 24457, 23039, 21622, 20202, 18784, 17368, 15949, 14532, 13116, 11697, 10282, 8789, 7811, 4276, -344, 164, 61, 56, 50, 46, 41, 37, 34, 30, 25, 22, 22, 18, 16, 14, 10, 11, 8, 6, 4, 2, 1, 1, -2, -2, -3, -5, -7, -9, -12, -11, -15, -17, -19, -23, -23, -26, -31, -35, -38, -42, -47, -51, -57, -62, -165, 343, -4277, -7812, -8789, -10282, -11698, -13116, -14532, -15949, -17369, -18785, -20202, -21623, -23039, -24457, -25878, -27294, -28708, -30106, -31629, -31335, -29789, -28427, -27028, -25630, -24234, -22833, -21432, -20032, -18629, -17226, -15826, -14422, -13018, -11617, -10211, -8806, -7404, -5996, -4591, -3195, -1755, -501, -362, -389, -380, -381, -380, -380, -380, -380, -381, -380, -382, -384, -383, -383, -383, -383, -383, -400, -324, -887, -2377, -3804, -5240, -6673, -8111, -9546, -10979, -12416, -13850, -15282, -16718, -18148, -19579, -21014, -22441, -23872, -25303, -26729, -28157, -29579, -31007, -32439, -31760, -30181, -28760, -27310, -25863, -24409, -22958, -21510, -20057, -18606, -17158, -15703, -14251, -12804, -11351, -9900, -8450, -7000, -5554, -4078};