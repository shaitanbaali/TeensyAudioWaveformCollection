/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1599 256 samples */
 
const int16_t AKWF_1599_256_DATA [256] = 
{11667, 11673, 11677, 11680, 11684, 11687, 11691, 11900, 10744, 15829, 33444, 32635, 32757, 32767, 32767, 32768, 32767, 32767, 32767, 32765, 32763, 32762, 32760, 32757, 32755, 32753, 32749, 32747, 32744, 32741, 32738, 32735, 32732, 32728, 32725, 32722, 32718, 32716, 32711, 32708, 32704, 32701, 32697, 32694, 32690, 32686, 32682, 32679, 32675, 32612, 32845, 32100, 13548, 11089, 11710, 11589, 11588, 11586, 11586, 11584, 11583, 11582, 11582, 11582, 11582, 11582, 11582, 11582, 11583, 11585, 11584, 11586, 11587, 11588, 11589, 11589, 11591, 11592, 11594, 11595, 11595, 11598, 11599, 11600, 11603, 11603, 11605, 11606, 11607, 11609, 11611, 11612, 11616, 11616, 11617, 11619, 11620, 11622, 11624, 11625, 11626, 11629, 11630, 11632, 11633, 11634, 11636, 11638, 11638, 11641, 11642, 11644, 11645, 11647, 11648, 11649, 11650, 11650, 11644, 11595, 11976, 2145, -512, 101, -7, -4, -3, -1, 0, 2, 3, 6, -102, 511, -2146, -11976, -11596, -11645, -11651, -11650, -11649, -11649, -11648, -11646, -11644, -11643, -11641, -11639, -11638, -11637, -11635, -11634, -11633, -11631, -11629, -11627, -11625, -11625, -11622, -11621, -11619, -11618, -11616, -11616, -11613, -11612, -11610, -11608, -11607, -11605, -11604, -11603, -11601, -11600, -11598, -11595, -11596, -11595, -11593, -11591, -11590, -11589, -11589, -11587, -11586, -11585, -11586, -11584, -11582, -11583, -11582, -11582, -11583, -11582, -11583, -11583, -11585, -11587, -11587, -11589, -11589, -11710, -11090, -13548, -32100, -32845, -32612, -32675, -32679, -32682, -32686, -32690, -32694, -32697, -32701, -32704, -32708, -32711, -32716, -32718, -32722, -32725, -32728, -32732, -32735, -32738, -32741, -32744, -32747, -32749, -32753, -32755, -32757, -32760, -32762, -32763, -32765, -32767, -32767, -32767, -32768, -32767, -32767, -32757, -32635, -33443, -15829, -10745, -11900, -11691, -11688, -11684, -11680, -11677, -11673, -11668};