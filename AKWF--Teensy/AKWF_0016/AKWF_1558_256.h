/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1558 256 samples */
 
const int16_t AKWF_1558_256_DATA [256] = 
{1096, 2486, 3600, 4524, 5281, 5911, 6431, 6854, 7204, 7494, 7731, 7927, 8086, 8217, 8326, 8414, 8486, 8542, 8591, 8628, 8659, 8682, 8701, 8716, 8728, 8736, 8741, 8746, 8746, 8747, 8746, 8746, 8744, 8741, 8738, 8734, 8730, 8725, 8721, 8717, 8711, 8706, 8702, 8695, 8689, 8684, 8677, 8671, 8667, 8660, 8654, 8650, 8644, 8637, 8632, 8626, 8620, 8614, 8608, 8601, 8595, 8589, 8583, 8578, 8572, 8566, 8561, 8554, 8549, 8543, 8537, 8530, 8525, 8518, 8512, 8507, 8501, 8494, 8489, 8483, 8477, 8472, 8484, 7698, 11713, -16924, -35657, -32127, -32766, -32764, -32759, -32753, -32746, -32737, -32729, -32718, -32709, -32696, -32683, -32671, -32657, -32348, -33963, -23852, -23510, -21231, -15217, -11116, -7635, -4791, -2429, -468, 1137, 2464, 3565, 4464, 5210, 5825, 6333, 6753, 7097, 7379, 7613, 7807, 7964, 8093, 8199, 8287, 8358, 8416, 8462, 8500, 8530, 8556, 8573, 8589, 8602, 8610, 8615, 8619, 8621, 8623, 8622, 8622, 8620, 8618, 8614, 8611, 8607, 8601, 8598, 8593, 8588, 8583, 8577, 8573, 8568, 8562, 8556, 8551, 8546, 8540, 8534, 8528, 8523, 8517, 8511, 8505, 8499, 8493, 8487, 8481, 8475, 8470, 8463, 8458, 8452, 8446, 8440, 8434, 8429, 8423, 8418, 8411, 8405, 8400, 8394, 8388, 8382, 8376, 8370, 8365, 8359, 8352, 8355, 7879, 10539, -20780, -34953, -32282, -32762, -32759, -32754, -32748, -32741, -32732, -32723, -32714, -32702, -32689, -32677, -32665, -32650, -32637, -32623, -32607, -32591, -32577, -32561, -32541, -31988, -34852, -3396, 11001, 8062, 8600, 8612, 8620, 8625, 8630, 8633, 8636, 8639, 8639, 8637, 8639, 8638, 8637, 8636, 8633, 8631, 8628, 8625, 8621, 8613, 8111, 10966, -8124, -27977, -18831, -14526, -10467, -7144, -4361, -2148, -493};