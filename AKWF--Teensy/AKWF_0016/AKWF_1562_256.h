/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1562 256 samples */
 
const int16_t AKWF_1562_256_DATA [256] = 
{9254, 10559, 9864, 10052, 10054, 10061, 10064, 10068, 10072, 10075, 10078, 10081, 10082, 10083, 10083, 10066, 9803, 11570, -3487, -28204, -24614, -21153, -18386, -15792, -13391, -11238, -9319, -7514, -5901, -4432, -3084, -1676, -525, 443, 1342, 2177, 2914, 3597, 4208, 4767, 5279, 5731, 6151, 6530, 6873, 7189, 7469, 7730, 7961, 8171, 8366, 8538, 8696, 8839, 8968, 9087, 9191, 9286, 9374, 9452, 9525, 9586, 9646, 9699, 9744, 9787, 9825, 9857, 9890, 9915, 9940, 9962, 9981, 9998, 10014, 10026, 10039, 10049, 10057, 10064, 10072, 10076, 10081, 10086, 10088, 10089, 10091, 10091, 10092, 10092, 10093, 10092, 10090, 10088, 10087, 10084, 10082, 10078, 10076, 10074, 10071, 10067, 10064, 10060, 10057, 10052, 10048, 10045, 10041, 10036, 10032, 10029, 10024, 10019, 10015, 10010, 10006, 10003, 9997, 9993, 9988, 9983, 9979, 9974, 9970, 9964, 9961, 9956, 9949, 9946, 9942, 9937, 9932, 9927, 9924, 9917, 9912, 9908, 9902, 9898, 9894, 9888, 9885, 9879, 9874, 9870, 9865, 9858, 9855, 9850, 9844, 9841, 9836, 9831, 9827, 9821, 9816, 9812, 9805, 9802, 9797, 9792, 9787, 9783, 9778, 9774, 9768, 9763, 9760, 9754, 9749, 9745, 9739, 9734, 9730, 9725, 9721, 9716, 9710, 9707, 9701, 9696, 9692, 9687, 9682, 9678, 9672, 9669, 9665, 9658, 9654, 9649, 9644, 9640, 9636, 9629, 9625, 9620, 9615, 9612, 9606, 9601, 9638, 8975, 11883, 2120, -32467, -32656, -32678, -32761, -32766, -32764, -32761, -32757, -32754, -32749, -32743, -32735, -32729, -32722, -32713, -32706, -32697, -32687, -32680, -32670, -32660, -32649, -32639, -32628, -32618, -32608, -32595, -32583, -32573, -32561, -32550, -32537, -32525, -32515, -32502, -32489, -32476, -32464, -32453, -32440, -32429, -32414, -32401, -32388, -32376, -32364, -32352, -32164, -32857, -28344};