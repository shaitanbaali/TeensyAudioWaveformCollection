/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1594 256 samples */
 
const int16_t AKWF_1594_256_DATA [256] = 
{1010, 3194, 5276, 7023, 8837, 10692, 12571, 14442, 16284, 18057, 19712, 21211, 22569, 23835, 25023, 26128, 27147, 28087, 28944, 29713, 30396, 30987, 31488, 31903, 32230, 32474, 32642, 32737, 32768, 32746, 32674, 32559, 32409, 32230, 32024, 31795, 31547, 31282, 31001, 30710, 30411, 30108, 29812, 29531, 29277, 29071, 28928, 28845, 28788, 28724, 28645, 28554, 28464, 28421, 28435, 28483, 28547, 28616, 28681, 28740, 28792, 28841, 28431, 27811, 27389, 27091, 26639, 26064, 25413, 24701, 23937, 23140, 22325, 21507, 20701, 19910, 19139, 18389, 17654, 16931, 16219, 15455, 14599, 13678, 12715, 11732, 10737, 9730, 8721, 7710, 6697, 5693, 4697, 3712, 2746, 1803, 882, -8, -868, -1702, -2502, -3275, -4016, -4725, -5401, -6042, -6639, -7185, -7668, -8068, -8363, -8526, -8568, -8535, -8439, -8278, -8049, -7721, -7270, -6705, -6050, -5333, -4567, -3770, -2952, -2118, -1274, -425, 424, 1273, 2117, 2951, 3769, 4567, 5332, 6049, 6704, 7270, 7720, 8048, 8277, 8438, 8535, 8567, 8525, 8363, 8067, 7667, 7184, 6638, 6041, 5400, 4724, 4015, 3274, 2501, 1701, 867, 7, -883, -1804, -2747, -3713, -4698, -5694, -6698, -7710, -8722, -9731, -10738, -11732, -12715, -13678, -14599, -15455, -16220, -16932, -17654, -18389, -19140, -19911, -20701, -21507, -22326, -23141, -23938, -24701, -25413, -26065, -26639, -27091, -27389, -27812, -28432, -28841, -28792, -28740, -28682, -28616, -28548, -28483, -28435, -28421, -28464, -28554, -28646, -28724, -28788, -28845, -28928, -29071, -29278, -29532, -29812, -30108, -30411, -30710, -31001, -31282, -31547, -31795, -32024, -32230, -32409, -32559, -32674, -32746, -32768, -32737, -32642, -32474, -32230, -31903, -31488, -30987, -30396, -29713, -28944, -28087, -27147, -26128, -25023, -23835, -22569, -21211, -19712, -18058, -16285, -14443, -12571, -10693, -8838, -7024, -5276, -3195, -1011};