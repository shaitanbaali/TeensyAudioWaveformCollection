/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1549 256 samples */
 
const int16_t AKWF_1549_256_DATA [256] = 
{371, 1345, 2030, 2611, 3087, 3480, 3803, 4072, 4293, 4472, 4623, 4747, 4846, 4929, 4998, 5054, 5099, 5136, 5166, 5191, 5211, 5226, 5238, 5248, 5256, 5261, 5266, 5269, 5269, 5272, 5272, 5271, 5271, 5269, 5268, 5265, 5263, 5262, 5258, 5254, 5252, 4904, 6814, -2458, -28454, -22072, -17315, -13407, -10139, -7462, -5233, -3396, -1876, -628, 401, 1251, 1955, 2532, 3012, 3407, 3731, 3999, 4220, 4403, 4552, 4675, 4776, 4860, 4928, 4982, 5030, 5067, 5096, 5121, 5141, 5155, 5169, 5180, 5187, 5193, 5196, 5199, 5201, 5202, 5202, 5202, 5201, 5200, 5199, 5197, 5195, 5192, 5189, 5188, 5185, 5181, 5178, 5176, 5172, 5168, 5166, 5163, 5160, 5157, 5154, 5150, 5148, 5144, 5141, 5138, 5134, 5131, 5128, 5124, 5121, 5119, 5114, 5111, 5108, 5104, 5101, 5099, 5095, 5092, 5089, 5084, 5081, 5078, 5076, 5072, 5068, 5066, 5062, 5059, 5057, 4518, 7402, -10846, -34739, -32316, -32752, -32757, -32752, -32744, -32735, -32726, -32716, -32705, -32693, -32679, -32666, -32652, -32637, -32623, -32608, -32592, -32576, -32560, -32542, -32525, -32022, -34652, -18581, 7234, 4939, 5334, 5363, 5372, 5380, 5386, 5392, 5397, 5401, 5405, 5406, 5408, 5410, 5410, 5412, 5412, 5411, 5410, 5410, 5410, 5408, 5407, 5405, 5403, 5401, 5400, 5398, 5395, 5392, 5391, 5389, 5385, 5382, 5380, 5377, 5374, 5371, 5368, 5365, 5362, 5359, 5356, 5353, 5351, 5345, 5341, 5339, 5336, 5332, 5329, 5326, 5323, 5319, 5316, 5313, 5309, 5306, 5303, 5299, 5296, 5293, 5289, 5287, 5284, 5280, 5277, 5275, 5270, 5267, 5264, 5261, 5256, 5252, 5250, 5246, 5243, 5240, 5236, 5237, 4776, 7351, -5887, -30125, -22001, -17540, -13601, -10307, -7580, -5335, -3486, -1962, -689};