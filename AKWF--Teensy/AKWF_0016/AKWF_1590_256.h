/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1590 256 samples */
 
const int16_t AKWF_1590_256_DATA [256] = 
{84, 426, 951, 1575, 2253, 2961, 3685, 4415, 5150, 5887, 6623, 7360, 8098, 8840, 9593, 10367, 11182, 12083, 13138, 14417, 15874, 17257, 18393, 19315, 20099, 20803, 21458, 22081, 22676, 23252, 23808, 24344, 24865, 25364, 25838, 26287, 26696, 27050, 27313, 27426, 27305, 26944, 26539, 26320, 26316, 26444, 26641, 26866, 27100, 27333, 27557, 27769, 27971, 28159, 28335, 28500, 28659, 28818, 28994, 29212, 29521, 30005, 30712, 31511, 32152, 32528, 32708, 32766, 32749, 32682, 32579, 32445, 32285, 32102, 31896, 31666, 31410, 31128, 30810, 30446, 30018, 29479, 28761, 27792, 26621, 25498, 24597, 23885, 23283, 22735, 22209, 21692, 21175, 20649, 20118, 19579, 19031, 18478, 17921, 17365, 16823, 16310, 15860, 15535, 15417, 15515, 15631, 15535, 15200, 14707, 14120, 13480, 12809, 12113, 11402, 10680, 9946, 9201, 8449, 7681, 6901, 6098, 5257, 4354, 3338, 2129, 678, -883, -2307, -3483, -4480, -5373, -6207, -7007, -7786, -8550, -9302, -10046, -10777, -11498, -12208, -12899, -13569, -14203, -14779, -15256, -15564, -15625, -15496, -15419, -15568, -15915, -16377, -16894, -17440, -17996, -18552, -19105, -19652, -20189, -20721, -21244, -21761, -22280, -22806, -23360, -23973, -24703, -25637, -26782, -27935, -28871, -29560, -30079, -30498, -30855, -31167, -31446, -31698, -31924, -32128, -32308, -32464, -32594, -32693, -32755, -32763, -32693, -32492, -32081, -31409, -30607, -29927, -29472, -29179, -28969, -28797, -28638, -28479, -28313, -28135, -27945, -27742, -27528, -27302, -27070, -26835, -26612, -26422, -26307, -26335, -26585, -27001, -27337, -27422, -27285, -27007, -26645, -26229, -25777, -25299, -24796, -24274, -23735, -23175, -22598, -22000, -21372, -20713, -20001, -19201, -18258, -17086, -15677, -14235, -12985, -11955, -11072, -10262, -9492, -8742, -7999, -7262, -6527, -5789, -5053, -4319, -3588, -2867, -2163, -1488, -875, -369, -54, 16, -16};