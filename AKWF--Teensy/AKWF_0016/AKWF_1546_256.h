/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1546 256 samples */
 
const int16_t AKWF_1546_256_DATA [256] = 
{601, 1909, 2950, 3813, 4525, 5117, 5603, 6003, 6335, 6606, 6829, 7014, 7167, 7292, 7395, 7478, 7552, 7042, 10193, -9475, -28339, -19071, -14894, -10892, -7593, -4889, -2664, -782, 508, 1676, 2810, 3713, 4463, 5081, 5590, 6013, 6360, 6641, 6878, 7070, 7231, 7360, 7466, 7554, 7626, 7683, 7731, 7769, 7800, 7824, 7844, 7860, 7872, 7881, 7888, 7893, 7894, 7897, 7898, 7897, 7896, 7896, 7892, 7890, 7887, 7884, 7881, 7877, 7873, 7868, 7865, 7860, 7855, 7851, 7848, 7843, 7835, 7832, 7828, 7823, 7818, 7814, 7809, 7802, 7799, 7794, 7789, 7785, 7780, 7774, 7770, 7766, 7760, 7755, 7751, 7746, 7740, 7735, 7731, 7726, 7720, 7717, 7712, 7706, 7701, 7698, 7692, 7687, 7683, 7679, 7667, 7135, 10056, -10973, -34810, -32305, -32746, -32761, -32755, -32750, -32742, -32732, -32723, -32712, -32701, -32689, -32675, -32661, -32647, -32632, -32618, -32603, -32587, -32570, -32554, -32532, -32047, -34583, -5944, 10440, 7384, 7956, 7959, 7967, 7974, 7980, 7983, 7986, 7990, 7991, 7992, 7994, 7993, 7993, 7993, 7991, 7990, 7988, 7985, 7983, 7981, 7978, 7975, 7972, 7968, 7965, 7960, 7957, 7954, 7948, 7946, 7940, 7935, 7932, 7927, 7923, 7919, 7914, 7910, 7905, 7901, 7896, 7891, 7886, 7882, 7877, 7873, 7868, 7863, 7858, 7854, 7849, 7844, 7839, 7834, 7829, 7825, 7819, 7815, 7809, 7805, 7799, 7795, 7790, 7786, 7780, 7776, 7771, 7766, 7762, 7757, 7752, 7748, 7743, 7738, 7732, 7727, 7723, 7718, 7713, 7709, 7704, 7698, 7694, 7689, 7685, 7680, 7675, 7670, 7667, 7425, 8501, 4007, -28640, -33466, -32422, -32645, -32642, -32637, -32629, -32620, -32611, -32601, -32590, -32578, -32541, -32581, -32380, -26226, -19897, -15107, -11092, -7769, -5025, -2777, -895};