/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1511 256 samples */
 
const int16_t AKWF_1511_256_DATA [256] = 
{6552, 6553, 6552, 6552, 6553, 6552, 6553, 6553, 6553, 6553, 6552, 6552, 6553, 6622, 6228, 7988, 13374, 13050, 13103, 13105, 13105, 13106, 13105, 13106, 13105, 13106, 13130, 13133, 12912, 22909, 26834, 26068, 26212, 26212, 26212, 26212, 26212, 26212, 26212, 26212, 26212, 26212, 26212, 26212, 26212, 26212, 26228, 26168, 26341, 32096, 32936, 32725, 32764, 32764, 32765, 32765, 32764, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32764, 32765, 32765, 32765, 32764, 32765, 32765, 32765, 32765, 32764, 32765, 32765, 32725, 33005, 31671, 28233, 30649, 25697, 26318, 26136, 26563, 24620, 19339, 19726, 19659, 19659, 19658, 19539, 20176, 15976, 12601, 13221, 13105, 13105, 13106, 13106, 13105, 13105, 13105, 12993, 13600, 9068, 6078, 6660, 6552, 6553, 6553, 6553, 6552, 6552, 6553, 6553, 6552, 6552, 6552, 6552, 6552, 6552, 6552, 6553, 6464, 6956, 1915, -490, 489, -1916, -6957, -6465, -6554, -6552, -6553, -6553, -6553, -6553, -6553, -6553, -6553, -6553, -6553, -6553, -6553, -6554, -6553, -6553, -6661, -6079, -9069, -13601, -12994, -13106, -13106, -13106, -13106, -13107, -13106, -13106, -13221, -12602, -15977, -20177, -19540, -19659, -19660, -19659, -19726, -19339, -24620, -26563, -26137, -26318, -25697, -30649, -28233, -31671, -33005, -32725, -32764, -32765, -32764, -32765, -32765, -32765, -32765, -32764, -32765, -32764, -32764, -32764, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32764, -32765, -32765, -32764, -32764, -32725, -32936, -32096, -26341, -26169, -26229, -26212, -26212, -26212, -26212, -26212, -26212, -26212, -26212, -26213, -26212, -26212, -26213, -26212, -26212, -26068, -26834, -22909, -12913, -13133, -13130, -13106, -13106, -13106, -13106, -13107, -13106, -13106, -13104, -13051, -13375, -7989, -6229, -6623, -6554, -6553, -6553, -6554, -6553, -6554, -6553, -6553, -6554, -6553, -6553, -6554, -6552};