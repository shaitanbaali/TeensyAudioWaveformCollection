/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1555 256 samples */
 
const int16_t AKWF_1555_256_DATA [256] = 
{436, 1254, 1977, 2608, 3174, 3672, 4117, 4504, 4850, 5149, 5420, 5657, 5869, 6051, 6216, 6358, 6487, 6598, 6699, 6784, 6861, 6927, 6988, 7039, 7086, 7125, 7160, 7189, 7218, 7242, 7260, 7278, 7293, 7305, 7316, 7326, 7333, 7340, 7344, 7350, 7352, 7355, 7359, 7358, 7361, 7362, 7361, 7360, 7359, 7357, 7357, 7355, 7354, 7351, 7348, 7346, 7344, 7342, 7339, 7336, 7332, 7330, 7327, 7324, 7320, 7318, 7315, 7310, 7308, 7304, 7301, 7297, 7294, 7291, 7287, 7285, 7281, 7279, 7275, 7270, 7265, 7263, 7260, 7256, 7254, 7249, 7245, 7242, 7238, 7235, 7232, 7229, 7224, 7220, 7217, 7214, 7210, 7206, 7204, 7201, 7196, 7193, 7190, 7186, 7183, 7179, 7175, 7171, 7168, 7165, 7161, 7158, 7155, 7152, 7148, 7144, 7140, 7136, 7133, 7131, 7126, 7123, 7119, 7116, 7112, 7109, 7106, 7103, 7098, 7109, 6621, 9174, -8914, -33533, -32570, -32715, -32762, -32760, -32757, -32752, -32746, -32739, -32730, -32724, -32716, -32706, -32696, -32687, -32675, -32663, -32653, -32640, -32628, -32616, -32604, -32591, -32579, -32565, -32552, -32538, -32525, -32510, -32496, -32483, -32469, -32453, -32440, -32426, -32407, -32010, -33910, -19898, 7765, 7537, 7390, 7500, 7510, 7518, 7525, 7530, 7534, 7538, 7543, 7547, 7548, 7551, 7552, 7554, 7554, 7554, 7554, 7554, 7552, 7552, 7551, 7550, 7549, 7548, 7547, 7545, 7542, 7540, 7538, 7535, 7534, 7532, 7529, 7527, 7522, 7520, 7516, 7515, 7512, 7509, 7505, 7503, 7500, 7497, 7492, 7490, 7486, 7483, 7480, 7477, 7473, 7471, 7466, 7463, 7459, 7456, 7454, 7449, 7445, 7443, 7438, 7435, 7431, 7428, 7424, 7305, 7555, 7383, -19541, -29165, -22667, -19648, -16486, -13710, -11269, -9086, -7187, -5486, -3988, -2665, -1498, -438};