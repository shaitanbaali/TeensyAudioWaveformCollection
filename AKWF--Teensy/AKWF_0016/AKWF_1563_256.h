/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1563 256 samples */
 
const int16_t AKWF_1563_256_DATA [256] = 
{612, 1885, 5092, 9310, 13085, 14718, 13778, 11198, 8602, 7289, 7563, 8726, 9692, 9706, 8749, 7386, 6351, 6067, 6468, 7096, 7463, 7342, 6857, 6339, 6094, 6223, 6607, 6996, 7192, 7166, 7020, 6919, 6979, 7196, 7478, 7715, 7838, 7876, 7877, 7925, 8046, 8227, 8418, 8571, 8658, 8702, 8755, 8830, 8938, 9061, 9178, 9259, 9314, 9360, 9406, 9468, 9541, 9611, 9671, 9718, 9752, 9779, 9804, 9842, 9885, 9913, 9935, 9952, 9962, 9968, 9975, 9983, 9988, 9984, 9983, 9974, 9954, 9947, 9933, 9922, 9901, 9878, 9854, 9827, 9798, 9763, 9730, 9693, 9658, 9613, 9569, 9522, 9472, 9423, 9373, 9317, 9263, 9206, 9149, 9083, 9021, 8956, 8891, 8823, 8758, 8683, 8613, 8540, 8462, 8387, 8305, 8224, 8141, 8062, 7983, 7892, 7803, 7717, 7634, 7544, 7452, 7361, 7262, 7175, 7081, 6982, 6888, 6790, 6689, 6591, 6489, 6385, 6285, 6184, 6078, 5975, 5867, 5766, 5658, 5549, 5443, 5332, 5221, 5119, 5005, 4896, 4784, 4669, 4559, 4447, 4330, 4220, 4107, 3988, 3872, 3760, 3642, 3525, 3404, 3287, 3169, 3055, 2935, 2816, 2695, 2578, 2459, 2336, 2215, 2095, 1976, 1857, 1736, 1612, 1491, 1369, 1246, 1130, 1003, 876, 755, 633, 511, 390, 265, 145, 24, -99, -219, -340, -458, -583, -707, -833, -953, -1075, -1196, -1321, -1441, -1558, -1685, -1810, -1929, -2047, -2170, -2290, -2414, -2534, -2655, -2769, -3242, -1599, -11409, -29860, -29990, -30650, -31196, -31616, -31965, -32246, -32459, -32607, -32712, -32761, -32760, -32717, -32635, -32521, -32377, -32203, -31981, -31747, -31487, -31207, -30911, -30603, -30273, -29934, -29582, -29218, -28850, -28472, -28083, -27693, -27300, -26899, -26497, -26094, -25691, -25284, -24884, -24478, -24089, -23396, -24503, -15026};