/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1586 256 samples */
 
const int16_t AKWF_1586_256_DATA [256] = 
{14816, 21838, 22762, 26502, 30362, 32631, 32272, 29692, 26327, 23825, 22996, 23477, 24247, 24292, 23244, 21477, 19759, 18703, 18434, 18636, 18771, 18467, 17708, 16753, 15967, 15564, 15504, 15565, 15515, 15230, 14758, 14273, 13923, 13755, 13717, 13677, 13553, 13318, 13018, 12746, 12550, 12437, 12355, 12250, 12093, 11894, 11679, 11489, 11334, 11209, 11100, 10959, 10797, 10616, 10444, 10281, 10138, 10003, 9865, 9717, 9562, 9229, 9814, 6452, -15177, -19088, -19137, -19848, -20338, -20755, -21093, -21359, -21554, -21699, -21791, -21834, -21830, -21784, -21707, -21590, -21448, -21253, -21042, -20811, -20557, -20280, -19992, -19686, -19362, -19030, -18685, -18329, -17971, -17601, -17223, -16844, -16458, -16067, -15676, -15290, -14901, -14502, -14115, -13723, -13341, -12953, -12576, -12197, -11817, -11445, -11074, -10709, -10353, -10003, -9651, -9308, -8965, -8629, -8304, -7983, -7670, -7365, -7052, -6751, -6457, -6176, -5888, -5614, -5345, -5081, -4825, -4575, -4331, -4091, -3856, -3628, -3411, -3194, -2987, -2784, -2584, -2396, -2214, -2041, -1869, -1694, -1532, -1374, -1223, -1077, -930, -784, -655, -530, -401, -284, -168, -59, 47, 143, 239, 331, 416, 501, 583, 654, 726, 796, 859, 917, 971, 1030, 1081, 1121, 1162, 1199, 1234, 1263, 1293, 1318, 1335, 1349, 1369, 1379, 1382, 1397, 1400, 1404, 1401, 1396, 1391, 1382, 1371, 1356, 1339, 1321, 1302, 1275, 1248, 1217, 1185, 1155, 1120, 1083, 1046, 1004, 965, 914, 869, 822, 773, 721, 671, 612, 562, 499, 441, 381, 315, 251, 180, 120, 56, -18, -92, -161, -231, -308, -382, -462, -541, -614, -697, -779, -858, -944, -1026, -1112, -1199, -1286, -1373, -1461, -1551, -1643, -1734, -1822, -1917, -2012, -2102, -2197, -2296, -2385, -2484, -2558, -2756, -2566};