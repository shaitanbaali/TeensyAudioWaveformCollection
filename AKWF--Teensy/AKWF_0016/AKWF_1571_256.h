/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1571 256 samples */
 
const int16_t AKWF_1571_256_DATA [256] = 
{14347, 33110, 32153, 32020, 31866, 31660, 31465, 31262, 31068, 30872, 30675, 30486, 30289, 30100, 29913, 29723, 29538, 29351, 29165, 28986, 28804, 28622, 28445, 28267, 28093, 27918, 27741, 27571, 27400, 27231, 27064, 26896, 26730, 26567, 26402, 26243, 26084, 25923, 25766, 25608, 25454, 25301, 25145, 24997, 24848, 24699, 24553, 24404, 24265, 24079, 23804, 24615, 6816, -12601, -11409, -11197, -10978, -10702, -10216, -10823, -6082, 22982, 31928, 30091, 30205, 29999, 29786, 29582, 29375, 29166, 28972, 28765, 28568, 28369, 28181, 27975, 27786, 27598, 27407, 26859, 28785, 5387, -5649, -3479, -4115, -4296, -4464, -4635, -4805, -4972, -5140, -5303, -5466, -5628, -5784, -5944, -6101, -6254, -6408, -6559, -6709, -6858, -7005, -7149, -7297, -7438, -7583, -7718, -7858, -7998, -8133, -8268, -8398, -8532, -8662, -8791, -8919, -9046, -9169, -9295, -9420, -9540, -9660, -9777, -9898, -10015, -10131, -10245, -10360, -10471, -10581, -10694, -10805, -10914, -11020, -11126, -11231, -11333, -11440, -11543, -11643, -11744, -11843, -11940, -12037, -12134, -12228, -12323, -12416, -12509, -12598, -12690, -12778, -12866, -12952, -13040, -13127, -13211, -13296, -13380, -13463, -13545, -13625, -13706, -13785, -13863, -13943, -14020, -14094, -14171, -14245, -14318, -14392, -14464, -14535, -14606, -14670, -14747, -14341, -16880, -5581, 18581, 4778, -22575, -25259, -24035, -23851, -23451, -23051, -22660, -22268, -21883, -21502, -21122, -20748, -20374, -20006, -19641, -19278, -18920, -18564, -18209, -17862, -17515, -17168, -16832, -16492, -16159, -15828, -15499, -15174, -14851, -14525, -14212, -13897, -13586, -13276, -12968, -12666, -12365, -12067, -11771, -11475, -11187, -10900, -10614, -10333, -10050, -9774, -9502, -9229, -8959, -8694, -8428, -8168, -7907, -7650, -7397, -7143, -6892, -6646, -6399, -6156, -5913, -5676, -5441, -5201, -4971, -4738, -4508, -4284, -4055, -3837, -3597, -3448, -2834};