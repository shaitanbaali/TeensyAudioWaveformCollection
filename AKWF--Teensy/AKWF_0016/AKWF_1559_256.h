/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1559 256 samples */
 
const int16_t AKWF_1559_256_DATA [256] = 
{837, 2387, 3636, 4673, 5530, 6236, 6814, 7292, 7690, 8015, 8280, 8503, 8683, 8831, 8953, 9053, 9135, 9200, 9254, 9297, 9333, 9361, 9383, 9401, 9413, 9423, 9431, 9435, 9439, 9440, 9440, 9439, 9440, 9437, 9433, 9430, 9425, 9421, 9417, 9412, 9408, 9402, 9398, 9393, 9388, 9381, 9375, 9370, 9364, 9358, 9352, 9347, 9341, 9335, 9328, 9323, 9318, 9312, 9306, 9300, 9293, 9287, 9282, 9277, 9271, 9263, 9257, 9251, 9246, 9241, 9234, 9227, 9222, 9217, 9211, 9206, 9199, 9192, 9187, 9181, 9176, 9170, 9161, 8987, 9711, 7005, -27781, -33811, -32463, -32727, -32723, -32719, -32711, -32703, -32696, -32685, -32674, -32663, -32651, -32639, -32625, -32610, -32596, -32581, -32566, -32526, -32540, -32435, -21029, -24481, -18270, -13512, -9471, -6147, -3421, -1134, 959, 2481, 3733, 4771, 5625, 6328, 6911, 7391, 7787, 8116, 8382, 8604, 8786, 8934, 9058, 9160, 9241, 9308, 9363, 9406, 9442, 9472, 9495, 9513, 9525, 9536, 9545, 9551, 9553, 9556, 9556, 9556, 9555, 9552, 9549, 9545, 9542, 9537, 9532, 9528, 9524, 9518, 9513, 9508, 9503, 9498, 9493, 9486, 9480, 9474, 9469, 9463, 9458, 9453, 9447, 9439, 9433, 9427, 9422, 9417, 9410, 9404, 9398, 9393, 9386, 9380, 9374, 9368, 9362, 9356, 9350, 9343, 9337, 9332, 9326, 9320, 9314, 9308, 9303, 9296, 9290, 9285, 9279, 8958, 10576, 3082, -30717, -33185, -32618, -32764, -32764, -32757, -32750, -32743, -32733, -32722, -32710, -32699, -32687, -32675, -32661, -32647, -32633, -32619, -32602, -32587, -32570, -32554, -32266, -33544, -27449, 6641, 10242, 9316, 9542, 9550, 9557, 9563, 9566, 9570, 9573, 9574, 9576, 9576, 9575, 9574, 9571, 9570, 9567, 9522, 9336, 10863, -17936, -26090, -17498, -13201, -9212, -5920, -3219, -971};