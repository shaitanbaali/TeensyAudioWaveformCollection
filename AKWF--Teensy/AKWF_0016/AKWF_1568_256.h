/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1568 256 samples */
 
const int16_t AKWF_1568_256_DATA [256] = 
{276, 788, 1263, 1736, 2187, 2614, 3028, 3436, 3829, 4218, 4607, 4978, 5331, 5674, 5999, 6314, 6614, 6914, 7219, 7501, 7772, 8030, 8274, 8526, 8773, 8993, 9209, 9423, 9617, 9810, 9995, 10168, 10324, 10482, 10631, 10769, 10904, 11032, 11144, 11254, 11362, 11462, 11542, 11617, 11706, 11779, 11831, 11886, 11933, 11975, 12009, 12045, 12068, 12076, 12084, 12099, 12091, 12079, 12082, 12067, 12052, 12022, 11995, 11963, 11927, 11887, 11835, 11781, 11727, 11666, 11596, 11526, 11448, 11369, 11292, 11203, 11111, 11020, 10925, 10826, 10713, 10609, 10500, 10388, 10272, 10154, 10026, 9910, 9773, 9646, 9511, 9367, 9226, 9081, 8945, 8798, 8636, 8486, 8334, 8184, 8022, 7862, 7692, 7528, 7372, 7194, 7025, 6854, 6677, 6502, 6321, 6137, 5956, 5778, 5593, 5404, 5213, 5028, 4838, 4643, 4449, 4260, 4056, 3869, 3674, 3470, 3278, 3070, 2866, 2669, 2457, 2257, 2058, 1844, 1628, 1425, 1218, 1003, 787, 577, 358, 154, -58, -276, -495, -709, -921, -1140, -1368, -1586, -1803, -2019, -2236, -2456, -2683, -2901, -3126, -3341, -3561, -3790, -4017, -4237, -4463, -4681, -4908, -5132, -5348, -5573, -5796, -6020, -6232, -6457, -6686, -6912, -7133, -7359, -7575, -7798, -8030, -8238, -8467, -8694, -8917, -9131, -9355, -9574, -9790, -10018, -10239, -10454, -10860, -9872, -15461, -28639, -17380, -16462, -11020, -4327, 289, 243, -4165, -10542, -15741, -17862, -17140, -15383, -14607, -15778, -18441, -21266, -22916, -23004, -22022, -20944, -20563, -21068, -22008, -22696, -22701, -21991, -20952, -20057, -19565, -19428, -19375, -19104, -18473, -17579, -16651, -15861, -15268, -14829, -14360, -13771, -13023, -12206, -11414, -10716, -10123, -9569, -8993, -8358, -7673, -6972, -6314, -5710, -5152, -4617, -4062, -3490, -2908, -2320, -1770, -1258, -782, -281};