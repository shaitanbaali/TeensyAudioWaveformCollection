/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1525 256 samples */
 
const int16_t AKWF_1525_256_DATA [256] = 
{2051, 3940, 5155, 8422, 17567, 19232, 20148, 21629, 22732, 23114, 23175, 23462, 24046, 24740, 25117, 25266, 25295, 25534, 25903, 26316, 26593, 26807, 27044, 27410, 27858, 28313, 28724, 29110, 29530, 29990, 30468, 30905, 31296, 31634, 31951, 32240, 32482, 32648, 32740, 32769, 32747, 32663, 32493, 32483, 30419, 26770, 26627, 26753, 26350, 25105, 23838, 22857, 22429, 22240, 21850, 21227, 20552, 20208, 20091, 20095, 19937, 19721, 19505, 19448, 19456, 19450, 19333, 19144, 18942, 18754, 18554, 18276, 17910, 17481, 17033, 16563, 16067, 15532, 14962, 14374, 13807, 13259, 12732, 12222, 11738, 11297, 10908, 10567, 10274, 10021, 9810, 9644, 9516, 9412, 9329, 9255, 9185, 9110, 9025, 8914, 8774, 8601, 8392, 8138, 7848, 7512, 7138, 6728, 6283, 5815, 5330, 4834, 4334, 3837, 3357, 2895, 2463, 2060, 1696, 1368, 1083, 837, 636, 466, 324, 210, 120, 39, -40, -121, -211, -325, -467, -637, -838, -1084, -1369, -1697, -2061, -2464, -2896, -3358, -3838, -4335, -4835, -5331, -5816, -6284, -6729, -7139, -7513, -7849, -8139, -8393, -8601, -8775, -8914, -9026, -9110, -9186, -9256, -9330, -9413, -9516, -9645, -9811, -10021, -10275, -10568, -10908, -11297, -11739, -12222, -12733, -13260, -13808, -14375, -14962, -15532, -16067, -16563, -17033, -17482, -17910, -18277, -18555, -18754, -18942, -19144, -19334, -19451, -19457, -19448, -19505, -19721, -19937, -20095, -20091, -20209, -20552, -21227, -21850, -22240, -22429, -22857, -23838, -25106, -26350, -26753, -26627, -26770, -30419, -32483, -32493, -32663, -32747, -32769, -32740, -32648, -32482, -32240, -31951, -31634, -31296, -30905, -30468, -29990, -29530, -29110, -28724, -28313, -27858, -27411, -27045, -26807, -26593, -26316, -25903, -25534, -25296, -25266, -25117, -24740, -24046, -23462, -23175, -23114, -22732, -21629, -20148, -19232, -17567, -8423, -5155, -3941, -2052};