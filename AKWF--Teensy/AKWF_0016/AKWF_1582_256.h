/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1582 256 samples */
 
const int16_t AKWF_1582_256_DATA [256] = 
{19341, 23044, 25075, 32051, 20200, 2038, 1615, -2912, -7454, -10439, -11248, -10626, -9941, -10281, -11869, -14045, -15863, -16690, -16543, -15961, -15583, -15759, -16387, -17102, -17476, -17328, -16801, -16196, -15774, -15628, -15638, -15592, -15340, -14860, -14252, -13681, -13231, -12901, -12607, -12260, -11821, -11275, -10719, -10203, -9762, -9365, -8982, -8557, -8087, -7591, -7105, -6655, -6243, -5855, -5456, -5045, -4618, -4195, -3785, -3400, -3034, -2682, -2323, -1955, -1590, -1240, -899, -565, -260, 99, 431, 725, 1022, 1311, 1592, 1862, 2116, 2372, 2617, 2858, 3093, 3321, 3534, 3742, 3933, 4136, 4329, 4514, 4692, 4859, 5027, 5196, 5350, 5489, 5636, 5772, 5902, 6026, 6149, 6258, 6360, 6466, 6560, 6652, 6742, 6821, 6894, 6968, 7038, 7100, 7151, 7208, 7264, 7303, 7341, 7376, 7408, 7434, 7456, 7477, 7490, 7491, 7503, 7507, 7498, 7501, 7496, 7489, 7474, 7455, 7438, 7413, 7389, 7359, 7325, 7292, 7257, 7213, 7169, 7118, 7066, 7015, 6962, 6903, 6844, 6781, 6720, 6650, 6581, 6510, 6439, 6361, 6287, 6203, 6126, 6043, 5955, 5870, 5777, 5685, 5590, 5498, 5409, 5305, 5203, 5101, 5004, 4901, 4794, 4689, 4574, 4474, 4363, 4246, 4137, 4022, 3907, 3789, 3669, 3549, 3430, 3311, 3188, 3065, 2941, 2819, 2690, 2561, 2438, 2307, 2177, 2055, 1919, 1793, 1659, 1522, 1392, 1257, 1119, 991, 857, 711, 572, 440, 299, 159, 17, -122, -261, -397, -542, -686, -829, -969, -1110, -1258, -1402, -1547, -1689, -1831, -1975, -2125, -2269, -2417, -2563, -2701, -2851, -3005, -3149, -3297, -3445, -3589, -3740, -3882, -4027, -4176, -4322, -4468, -4610, -4761, -4910, -5060, -5205, -5351, -5494, -5647, -5790, -5933, -6085, -6228, -6379, -6521, -6668, -6674, -7513, -4750};