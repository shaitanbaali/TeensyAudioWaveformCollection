/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1524 256 samples */
 
const int16_t AKWF_1524_256_DATA [256] = 
{1290, 3975, 6697, 9450, 12048, 14442, 16813, 19189, 21618, 24008, 26215, 28014, 29378, 30276, 30805, 31185, 31608, 32020, 32324, 32498, 32504, 32544, 32695, 32757, 32585, 32258, 31703, 30896, 29960, 28934, 27859, 26875, 25964, 25030, 24059, 23041, 21858, 20573, 19309, 18043, 16916, 16054, 15298, 14539, 13752, 12848, 11759, 10581, 9339, 7949, 6443, 4951, 3608, 2367, 1085, -164, -1318, -2330, -3362, -4323, -5124, -5804, -6415, -6984, -7530, -8045, -8552, -9085, -9687, -10263, -10744, -10989, -10996, -10977, -11108, -11442, -11979, -12621, -13314, -14119, -15028, -16060, -17195, -18257, -19195, -20132, -20962, -21517, -21729, -21668, -21333, -20824, -20321, -19844, -19401, -19046, -18666, -18213, -17672, -17079, -16498, -16015, -15479, -14870, -14373, -14058, -13931, -13764, -13453, -13004, -12452, -11909, -11475, -11099, -10639, -10216, -9900, -9541, -9116, -8571, -7931, -7226, -6399, -5494, -4468, -3332, -2071, -694, 693, 2070, 3332, 4467, 5493, 6398, 7225, 7930, 8570, 9116, 9540, 9899, 10215, 10638, 11098, 11475, 11908, 12452, 13003, 13453, 13763, 13930, 14057, 14373, 14869, 15478, 16015, 16497, 17079, 17672, 18212, 18666, 19046, 19400, 19844, 20320, 20823, 21332, 21668, 21729, 21517, 20961, 20132, 19194, 18256, 17194, 16059, 15027, 14119, 13313, 12620, 11978, 11441, 11107, 10977, 10996, 10988, 10744, 10262, 9687, 9085, 8551, 8044, 7529, 6983, 6414, 5803, 5123, 4322, 3361, 2329, 1317, 163, -1086, -2368, -3609, -4952, -6444, -7949, -9340, -10582, -11759, -12849, -13752, -14539, -15298, -16054, -16916, -18043, -19309, -20573, -21859, -23041, -24060, -25031, -25964, -26876, -27859, -28934, -29960, -30896, -31703, -32258, -32585, -32757, -32695, -32544, -32504, -32498, -32324, -32020, -31608, -31185, -30805, -30276, -29378, -28015, -26215, -24009, -21618, -19190, -16813, -14443, -12049, -9450, -6698, -3976, -1291};