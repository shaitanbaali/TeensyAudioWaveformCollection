/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1512 256 samples */
 
const int16_t AKWF_1512_256_DATA [256] = 
{311, 986, 1779, 2748, 3717, 4657, 5568, 6431, 7240, 7988, 8727, 9485, 10268, 11076, 11864, 12596, 13109, 13502, 13890, 14261, 14621, 14968, 15301, 15625, 15938, 16241, 16536, 16820, 17098, 17368, 17630, 17887, 18140, 18386, 18628, 18867, 19103, 19337, 19571, 19801, 20028, 20256, 20486, 20719, 20954, 21192, 21434, 21679, 21928, 22181, 22439, 22700, 22967, 23237, 23511, 23790, 24074, 24362, 24652, 24947, 25245, 25547, 25850, 26157, 26466, 26775, 27084, 27395, 27706, 28016, 28325, 28631, 28935, 29236, 29531, 29824, 30110, 30390, 30664, 30930, 31187, 31431, 31664, 31886, 32098, 32299, 32387, 33069, 28554, 25976, 26326, 25288, 26886, 27139, 26437, 25801, 24979, 24337, 23807, 23266, 22685, 22078, 21453, 20820, 20179, 19535, 18891, 18246, 17600, 16953, 16316, 15614, 14622, 13534, 12461, 11456, 10544, 9669, 8737, 7753, 6734, 5699, 4656, 3627, 2757, 1976, 1202, 408, -409, -1203, -1977, -2758, -3627, -4657, -5700, -6735, -7754, -8737, -9669, -10545, -11456, -12462, -13535, -14622, -15614, -16317, -16954, -17600, -18247, -18891, -19535, -20180, -20821, -21454, -22078, -22685, -23267, -23808, -24337, -24980, -25801, -26437, -27139, -26886, -25288, -26326, -25976, -28554, -33069, -32387, -32299, -32098, -31886, -31664, -31431, -31187, -30930, -30664, -30390, -30110, -29824, -29531, -29236, -28935, -28631, -28325, -28016, -27706, -27395, -27085, -26775, -26466, -26157, -25850, -25547, -25245, -24947, -24653, -24362, -24074, -23791, -23511, -23238, -22967, -22700, -22439, -22181, -21928, -21680, -21434, -21193, -20955, -20719, -20486, -20257, -20029, -19801, -19571, -19338, -19103, -18868, -18629, -18387, -18140, -17888, -17630, -17368, -17098, -16821, -16536, -16242, -15939, -15625, -15302, -14969, -14622, -14262, -13891, -13503, -13109, -12597, -11865, -11076, -10269, -9485, -8728, -7988, -7241, -6432, -5568, -4658, -3718, -2749, -1780, -987, -312};