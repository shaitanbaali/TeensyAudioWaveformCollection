/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1550 256 samples */
 
const int16_t AKWF_1550_256_DATA [256] = 
{568, 1400, 2065, 2616, 3067, 3444, 3754, 4010, 4219, 4392, 4534, 4651, 4748, 4827, 4893, 4945, 4987, 5023, 5051, 5075, 5093, 5108, 5120, 5129, 5136, 5141, 5146, 5147, 5148, 5151, 5150, 5149, 5148, 5147, 5146, 5143, 5141, 5139, 5136, 5133, 5131, 5128, 5126, 5123, 5120, 5116, 5113, 5110, 5107, 5105, 5101, 5097, 5095, 5091, 5087, 5085, 5082, 5077, 5075, 5072, 5067, 5065, 5061, 5058, 5054, 5051, 5048, 5044, 5041, 5039, 5035, 5031, 5029, 5026, 5022, 5019, 5016, 5012, 5009, 5006, 4997, 4549, 7003, -17443, -34944, -32274, -32758, -32757, -32750, -32741, -32734, -32724, -32713, -32702, -32690, -32677, -32665, -32650, -32636, -32621, -32605, -32588, -32573, -32557, -32539, -32509, -32040, -34654, -12172, 7705, 4739, 5311, 5311, 5321, 5328, 5334, 5338, 5343, 5347, 5350, 5352, 5354, 5356, 5358, 5358, 5356, 5357, 5357, 5356, 5355, 5353, 5353, 5350, 5348, 5347, 5345, 5343, 5340, 5337, 5335, 5333, 5330, 5327, 5324, 5322, 5318, 5315, 5313, 5309, 5305, 5303, 5299, 5296, 5293, 5290, 5286, 5283, 5280, 5277, 5273, 5270, 5267, 5263, 5261, 5257, 5254, 5250, 5247, 5244, 5240, 5237, 5234, 5230, 5227, 5224, 5220, 5217, 5214, 5219, 4730, 7388, -6797, -28392, -20733, -16461, -12705, -9567, -6984, -4851, -3090, -1635, -440, 674, 1519, 2178, 2731, 3182, 3558, 3866, 4119, 4329, 4502, 4643, 4761, 4856, 4935, 5000, 5053, 5095, 5130, 5159, 5182, 5200, 5215, 5226, 5236, 5242, 5248, 5251, 5254, 5256, 5256, 5256, 5256, 5255, 5253, 5252, 5249, 5246, 5245, 5242, 5240, 5238, 5233, 5230, 5228, 5224, 5221, 5218, 5215, 5212, 5209, 5208, 4719, 7426, -8775, -28695, -20343, -16316, -12568, -9445, -6875, -4767, -3031, -1585, -381};