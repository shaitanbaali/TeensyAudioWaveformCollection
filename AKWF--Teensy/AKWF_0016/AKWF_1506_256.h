/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1506 256 samples */
 
const int16_t AKWF_1506_256_DATA [256] = 
{289, 871, 1380, 1798, 2105, 2295, 2377, 2375, 2318, 2248, 2205, 2221, 2321, 2516, 2804, 3167, 3575, 3994, 4382, 4701, 4929, 5051, 5064, 4989, 4856, 4708, 4591, 4555, 4636, 4862, 5241, 5767, 6411, 7125, 7864, 8566, 9175, 9655, 9975, 10128, 10131, 10018, 9836, 9643, 9499, 9454, 9543, 9783, 10165, 10659, 11215, 11768, 12254, 12611, 12791, 12769, 12551, 12166, 11675, 11153, 10694, 10386, 10305, 10505, 11012, 11810, 12851, 14058, 15324, 16543, 17603, 18417, 18926, 19108, 18986, 18620, 18104, 17549, 17074, 16784, 16757, 17028, 17590, 18383, 19308, 20236, 21026, 21545, 21686, 21387, 20644, 19517, 18121, 16620, 15209, 14089, 13434, 13384, 14006, 15299, 17174, 19476, 21999, 24488, 26718, 28480, 29622, 30085, 29884, 29119, 27965, 26647, 25419, 24530, 24192, 24544, 25598, 27220, 29120, 30920, 32226, 32771, 32477, 31631, 29936, 23890, 14714, 4912, -4913, -14714, -23890, -29936, -31631, -32477, -32771, -32227, -30920, -29120, -27220, -25599, -24544, -24193, -24530, -25419, -26647, -27965, -29119, -29884, -30085, -29623, -28480, -26718, -24488, -21999, -19477, -17175, -15300, -14006, -13384, -13435, -14090, -15209, -16620, -18122, -19517, -20644, -21387, -21686, -21545, -21026, -20236, -19309, -18383, -17591, -17029, -16758, -16785, -17075, -17549, -18104, -18620, -18987, -19109, -18926, -18417, -17603, -16543, -15325, -14058, -12851, -11811, -11013, -10506, -10306, -10387, -10695, -11154, -11676, -12167, -12552, -12770, -12792, -12612, -12255, -11769, -11215, -10659, -10166, -9784, -9544, -9455, -9500, -9644, -9837, -10018, -10132, -10129, -9976, -9656, -9176, -8567, -7864, -7126, -6411, -5768, -5242, -4863, -4637, -4556, -4592, -4709, -4856, -4990, -5065, -5052, -4930, -4702, -4382, -3995, -3576, -3168, -2805, -2517, -2322, -2222, -2206, -2248, -2319, -2376, -2378, -2296, -2106, -1799, -1381, -872, -290};