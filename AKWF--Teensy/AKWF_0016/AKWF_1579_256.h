/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1579 256 samples */
 
const int16_t AKWF_1579_256_DATA [256] = 
{2189, 1707, 1895, 1930, 1991, 2049, 2108, 2166, 2323, 1934, 4433, 16390, 19308, 18653, 18335, 19983, 30079, 33037, 32156, 31976, 31672, 31377, 31084, 30790, 30503, 30214, 29930, 29647, 29367, 29090, 28814, 28541, 28269, 27999, 27731, 27469, 27204, 26944, 26686, 26430, 26176, 25925, 25674, 25426, 25182, 24936, 24695, 24456, 24218, 23983, 23749, 23520, 23289, 23061, 22836, 22612, 22392, 22173, 21955, 21740, 21527, 21315, 21108, 20900, 20695, 20473, 20232, 20356, 12905, 4871, 5203, 5157, 5109, 5086, 5064, 5039, 5017, 4993, 4970, 4949, 4926, 4905, 4884, 4862, 4843, 4822, 4801, 4781, 4762, 4742, 4724, 4705, 4687, 4668, 4650, 4633, 4613, 4596, 4579, 4563, 4548, 4530, 4513, 4498, 4482, 4466, 4451, 4436, 4420, 4405, 4390, 4376, 4361, 4347, 4334, 4319, 4305, 4292, 4277, 4265, 4250, 4237, 4225, 4213, 4201, 4188, 4176, 4165, 4152, 4142, 4127, 3997, 4610, -557, -11670, -12470, -12016, -11913, -11734, -11554, -11380, -11205, -11030, -10859, -10688, -10521, -10352, -10186, -10021, -9858, -9696, -9535, -9376, -9292, -8755, -10051, -20739, -21238, -20876, -20774, -20626, -20478, -20328, -20181, -20036, -19892, -19747, -19607, -19463, -19324, -19186, -19047, -18910, -18774, -18638, -18507, -18374, -18242, -18113, -17983, -17856, -17730, -17603, -17478, -17355, -17231, -17111, -16991, -16873, -16752, -16635, -16520, -16405, -16291, -16178, -16064, -15953, -15845, -15734, -15627, -15519, -15411, -15307, -15203, -15100, -14996, -14893, -14792, -14693, -14595, -14498, -14398, -14302, -14207, -14112, -14019, -13925, -13834, -13743, -13653, -13563, -13473, -13387, -13299, -13213, -13128, -13043, -12958, -12875, -12792, -12710, -12630, -12549, -12469, -12391, -12312, -12235, -12159, -12083, -12007, -11932, -11858, -11785, -11711, -11641, -11569, -11499, -11430, -11360, -11293, -11225, -11158, -11093, -10936, -11353, -9227};