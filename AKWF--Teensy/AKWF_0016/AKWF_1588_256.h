/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1588 256 samples */
 
const int16_t AKWF_1588_256_DATA [256] = 
{8309, 20181, 20720, 24671, 29070, 32189, 32608, 30447, 27074, 24275, 23167, 23631, 24652, 25090, 24377, 22757, 21008, 19830, 19530, 19833, 20174, 20106, 19523, 18651, 17881, 17485, 17484, 17670, 17780, 17648, 17295, 16882, 16582, 16473, 16512, 16584, 16576, 16444, 16234, 16023, 15885, 15836, 15836, 15822, 15751, 15628, 15479, 15345, 15253, 15192, 15139, 15076, 14973, 14858, 14731, 14617, 14519, 14434, 14356, 14258, 14140, 14020, 13902, 13794, 13686, 13585, 13474, 13362, 13247, 13120, 12999, 12882, 12764, 12647, 12527, 12403, 12278, 12152, 12024, 11899, 11773, 11651, 11522, 11390, 11258, 11128, 10994, 10868, 10737, 10604, 10472, 10335, 10200, 10067, 9924, 9793, 9660, 9520, 9378, 9242, 9104, 8964, 8821, 8683, 8542, 8404, 8263, 8119, 7976, 7836, 7695, 7548, 7405, 7263, 7119, 6978, 6836, 6692, 6546, 6403, 6255, 6114, 5971, 5820, 5675, 5532, 5384, 5242, 5094, 4949, 4809, 4663, 4517, 4372, 4231, 4086, 3939, 3791, 3646, 3502, 3361, 3215, 3067, 2929, 2782, 2636, 2490, 2351, 2205, 2064, 1920, 1776, 1633, 1492, 1252, 1425, 220, -22332, -29179, -28826, -29634, -30146, -30570, -30919, -31196, -31396, -31542, -31631, -31664, -31644, -31580, -31482, -31344, -31183, -30965, -30722, -30459, -30171, -29862, -29539, -29197, -28834, -28465, -28081, -27685, -27286, -26873, -26452, -26033, -25607, -25173, -24739, -24306, -23876, -23436, -23006, -22570, -22143, -21711, -21292, -20872, -20450, -20035, -19622, -19213, -18818, -18428, -18032, -17649, -17266, -16892, -16531, -16169, -15816, -15474, -15124, -14786, -14455, -14137, -13813, -13504, -13199, -12903, -12613, -12326, -12051, -11777, -11509, -11249, -11001, -10752, -10512, -10280, -10052, -9833, -9622, -9417, -9222, -9017, -8827, -8642, -8463, -8293, -8120, -7948, -7790, -7642, -7488, -7348, -7203, -7073, -6945, -6818, -6712, -6555, -6573};