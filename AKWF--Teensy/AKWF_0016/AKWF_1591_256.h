/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1591 256 samples */
 
const int16_t AKWF_1591_256_DATA [256] = 
{7673, 10122, 12546, 14962, 17478, 17603, 17791, 18487, 20467, 19988, 19070, 18258, 17426, 16595, 15763, 14932, 14155, 13048, 13481, 16090, 15731, 15732, 16438, 12354, 7551, 6617, 5008, 3440, 2110, 4126, 3928, 3330, 3647, 4048, 4371, 4711, 5049, 5387, 5725, 6062, 6330, 6868, 3146, -4689, -9212, -6301, -4645, -2776, -911, 957, 2826, 4690, 6558, 8425, 10289, 12164, 13980, 16033, 18971, 19057, 18945, 18888, 18819, 18751, 18682, 18544, 18841, 16172, 14211, 13515, 6105, 4299, 3667, -35, -6701, -4045, 3231, 14751, 16457, 25262, 31900, 30017, 25663, 24012, 21883, 19822, 17766, 15705, 13646, 11656, 9237, 10629, 10397, 8275, 6019, 7452, 9749, 6673, -8986, -15165, -13153, -12596, -11986, -8852, -7203, -6678, -5918, -5189, -4462, -3739, -3015, -2291, -1565, -838, -111, 615, 1342, 2071, 2799, 3530, 4262, 4992, 5722, 6455, 7192, 7871, 8836, 8490, 6144, 4052, 1946, -951, -1579, -1436, -1515, -1544, -1574, -1606, -1636, -1665, -1693, -1721, -1916, -1009, -5679, -13071, -9778, -5703, -6972, -15626, -13607, -11469, -8863, -7467, -16468, -17968, -17893, -18439, -18845, -19264, -19676, -20088, -20497, -20905, -21327, -21742, -22157, -22571, -22985, -23305, -24199, -21868, -18038, -17522, -14965, -3763, -9109, -11058, -10043, -9718, -8855, -10423, -12228, -11528, -12750, -13161, -11922, -14378, -17113, -19771, -22441, -25106, -27672, -30618, -26960, -14832, -2562, -3246, -3708, -4329, -3872, -11487, -14725, -12503, -6008, 296, 4013, 11664, 11768, 6457, 4989, 3064, 1196, -663, -2515, -4373, -6226, -8073, -9916, -11756, -13578, -15324, -17526, -17244, -15267, -15921, -16185, -16506, -16826, -17148, -17467, -17785, -18104, -18423, -18740, -19057, -19374, -19689, -20003, -20319, -20634, -20955, -21214, -21739, -23309, -22198, -21097, -20007, -18914, -17820, -16722, -15626, -14532, -13260, -13107, -6941};