/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1508 256 samples */
 
const int16_t AKWF_1508_256_DATA [256] = 
{10921, 10922, 10921, 10922, 10922, 10921, 10922, 10921, 10922, 10921, 10921, 10922, 10922, 10922, 10922, 10921, 10922, 10921, 10921, 10921, 10920, 10921, 10922, 10922, 10922, 10921, 10921, 10921, 10921, 10921, 10922, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10922, 10921, 11120, 10059, 16180, 22660, 21783, 31549, 33074, 32695, 32766, 32765, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32765, 32765, 32766, 32765, 32766, 32766, 32765, 32766, 32765, 32766, 32766, 32766, 32766, 32765, 32765, 32766, 32765, 32766, 32616, 33226, 31305, -16788, -23157, -21538, -21844, -21844, -21844, -21844, -21844, -21846, -21844, -21649, -22702, -15558, -10093, -11112, -10921, -10922, -10922, -10922, -10922, -10923, -10922, -10922, -10923, -10922, -10923, -10921, -10922, -10923, -10747, -11698, -6876, 810, -183, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, -1, -1, 0, -1, 0, 0, 0, -1, 0, -1, 182, -811, 6875, 11697, 10746, 10922, 10922, 10921, 10922, 10922, 10922, 10921, 10921, 10922, 10921, 10921, 10922, 10922, 10921, 11112, 10092, 15558, 22702, 21649, 21844, 21845, 21843, 21844, 21844, 21843, 21844, 21537, 23156, 16788, -31305, -33226, -32616, -32766, -32765, -32766, -32765, -32765, -32766, -32766, -32766, -32766, -32765, -32766, -32765, -32766, -32766, -32765, -32766, -32765, -32765, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32765, -32766, -32695, -33074, -31549, -21783, -22660, -16181, -10059, -11120, -10922, -10922, -10922, -10921, -10922, -10921, -10922, -10921, -10922, -10922, -10922, -10921, -10922, -10921, -10922, -10922, -10922, -10923, -10922, -10922, -10921, -10922, -10921, -10922, -10922, -10922, -10923, -10923, -10922, -10923, -10922, -10922, -10922, -10922, -10923, -10921, -10922, -10923, -10922, -10922, -10922};