/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1557 256 samples */
 
const int16_t AKWF_1557_256_DATA [256] = 
{831, 2117, 3153, 4013, 4718, 5302, 5785, 6179, 6505, 6775, 6996, 7179, 7328, 7451, 7552, 7633, 7700, 7754, 7799, 7833, 7863, 7886, 7903, 7919, 7929, 7937, 7941, 7946, 7948, 7949, 7950, 7948, 7947, 7944, 7941, 7939, 7935, 7930, 7927, 7923, 7919, 7913, 7908, 7903, 7900, 7894, 7889, 7884, 7879, 7874, 7869, 7864, 7858, 7853, 7847, 7842, 7837, 7832, 7827, 7821, 7816, 7811, 7806, 7799, 7795, 7789, 7784, 7779, 7773, 7768, 7763, 7758, 7753, 7747, 7741, 7736, 7731, 7725, 7721, 7716, 7711, 7705, 7672, 7270, 9666, -20633, -35031, -32238, -32742, -32744, -32739, -32733, -32725, -32716, -32708, -32697, -32662, -32663, -32624, -22629, -26019, -19976, -15155, -11107, -7795, -5045, -2792, -916, 629, 1900, 2943, 3815, 4532, 5121, 5607, 6008, 6342, 6613, 6839, 7023, 7176, 7300, 7403, 7487, 7557, 7613, 7658, 7695, 7724, 7748, 7768, 7782, 7793, 7802, 7808, 7812, 7815, 7816, 7816, 7816, 7816, 7813, 7810, 7808, 7804, 7801, 7796, 7792, 7788, 7784, 7779, 7775, 7770, 7765, 7760, 7756, 7751, 7745, 7741, 7735, 7730, 7725, 7719, 7714, 7710, 7704, 7698, 7695, 7690, 7684, 7677, 7673, 7667, 7663, 7658, 7653, 7647, 7642, 7637, 7632, 7627, 7622, 7616, 7609, 7605, 7601, 7595, 7590, 7585, 7579, 7535, 7302, 9012, -19304, -34803, -32301, -32758, -32755, -32749, -32742, -32736, -32727, -32716, -32706, -32695, -32683, -32670, -32656, -32643, -32630, -32614, -32599, -32585, -32568, -32552, -32500, -32149, -34150, -7421, 10116, 7312, 7841, 7852, 7860, 7866, 7871, 7875, 7878, 7879, 7882, 7882, 7882, 7884, 7883, 7882, 7881, 7877, 7876, 7873, 7870, 7868, 7864, 7861, 7857, 7852, 7369, 10053, -5525, -28279, -19632, -15254, -11210, -7879, -5128, -2883, -779};