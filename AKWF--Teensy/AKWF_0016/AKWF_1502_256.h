/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1502 256 samples */
 
const int16_t AKWF_1502_256_DATA [256] = 
{3770, 6894, 8227, 9440, 10451, 11350, 12170, 12921, 13623, 14286, 14916, 15516, 16094, 16645, 17184, 17704, 18206, 18696, 19173, 19640, 20096, 20544, 20979, 21409, 21832, 22248, 22656, 23059, 23455, 23847, 24233, 24614, 24992, 25364, 25734, 26101, 26460, 26820, 27173, 27526, 27874, 28223, 28564, 28907, 29245, 29581, 29915, 30247, 30579, 30909, 31235, 31558, 31883, 32055, 33061, 28993, 18793, 16976, 17992, 18372, 18855, 19330, 19793, 20246, 20690, 21123, 21551, 21972, 22385, 22500, 24136, 18754, -6854, -17018, -14750, -14501, -13847, -13162, -12427, -11632, -10762, -9794, -8657, -7306, -5444, 1357, 6389, 7744, 9065, 10129, 11061, 11905, 12676, 13395, 14068, 14711, 15319, 15905, 16463, 17007, 17532, 18040, 18535, 19014, 19486, 19945, 20395, 20835, 21267, 21692, 22110, 22521, 22924, 23324, 23717, 24104, 24487, 24509, 26510, 16459, -8246, -13077, -11070, -10451, -9441, -8210, -6904, -3765, 3764, 6903, 8210, 9440, 10451, 11069, 13077, 8245, -16459, -26510, -24509, -24487, -24104, -23717, -23325, -22924, -22522, -22110, -21692, -21267, -20836, -20396, -19946, -19486, -19014, -18536, -18041, -17533, -17007, -16463, -15905, -15319, -14711, -14069, -13395, -12677, -11905, -11061, -10129, -9065, -7744, -6389, -1358, 5443, 7306, 8656, 9793, 10761, 11631, 12426, 13161, 13847, 14501, 14749, 17018, 6853, -18754, -24136, -22500, -22385, -21972, -21551, -21124, -20691, -20246, -19794, -19330, -18856, -18372, -17992, -16976, -18794, -28993, -33061, -32055, -31883, -31558, -31236, -30909, -30579, -30248, -29915, -29581, -29245, -28907, -28564, -28223, -27874, -27526, -27174, -26820, -26461, -26101, -25734, -25364, -24992, -24614, -24233, -23847, -23456, -23059, -22656, -22248, -21833, -21410, -20980, -20544, -20096, -19640, -19173, -18697, -18207, -17705, -17184, -16646, -16095, -15516, -14917, -14287, -13623, -12922, -12170, -11351, -10451, -9441, -8228, -6895, -3771};