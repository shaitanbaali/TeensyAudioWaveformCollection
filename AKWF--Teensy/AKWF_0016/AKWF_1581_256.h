/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1581 256 samples */
 
const int16_t AKWF_1581_256_DATA [256] = 
{49, 139, 225, 312, 397, 480, 564, 646, 727, 810, 889, 968, 1046, 1124, 1201, 1276, 1351, 1426, 1500, 1574, 1647, 1716, 1789, 1872, 2068, 1392, 10099, 21495, 21092, 20911, 20796, 20640, 20484, 20334, 20180, 20029, 19881, 19731, 19584, 19437, 19291, 19148, 19005, 18862, 18722, 18582, 18445, 18307, 18171, 18037, 17902, 17769, 17640, 17507, 17378, 17252, 17124, 16997, 16872, 16748, 16627, 16503, 16382, 16374, 15741, 19055, 30867, 32846, 32055, 31859, 31548, 31246, 30944, 30644, 30349, 30055, 29763, 29475, 29187, 28902, 28621, 28343, 28065, 27791, 27519, 27247, 26980, 26714, 26452, 26190, 25933, 25675, 25423, 25169, 24918, 24672, 24423, 24181, 23940, 23684, 23426, 23463, 10906, 7736, 8198, 7850, 7624, 7403, 7185, 6971, 6755, 6545, 6335, 6127, 5925, 5627, 5845, 3120, -9002, -12282, -11659, -11783, -11779, -11773, -11771, -11766, -11760, -11758, -11752, -11747, -11742, -11734, -11730, -11725, -11719, -11714, -11706, -11701, -11695, -11687, -11681, -11675, -11665, -11660, -11649, -11663, -11732, -11196, -20650, -31098, -30451, -30234, -30040, -29810, -29582, -29361, -29135, -28915, -28697, -28477, -28263, -28049, -27836, -27626, -27418, -27211, -27005, -26801, -26600, -26400, -26202, -26006, -25810, -25617, -25423, -25232, -25045, -24859, -24672, -24487, -24304, -24124, -23945, -23765, -23589, -23416, -23242, -23068, -22898, -22729, -22560, -22395, -22231, -22067, -21904, -21745, -21586, -21428, -21274, -20906, -21862, -16664, -5425, -6208, -5901, -5756, -5612, -5468, -5327, -5187, -5049, -4913, -4777, -4643, -4509, -4377, -4247, -4119, -3993, -3864, -3738, -3616, -3493, -3371, -3251, -3131, -3013, -2897, -2780, -2665, -2552, -2438, -2328, -2217, -2108, -2000, -1892, -1786, -1681, -1577, -1474, -1372, -1271, -1170, -1070, -972, -875, -779, -684, -589, -494, -401, -309, -218, -127, -37};