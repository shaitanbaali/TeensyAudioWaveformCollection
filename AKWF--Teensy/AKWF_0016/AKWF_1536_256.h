/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1536 256 samples */
 
const int16_t AKWF_1536_256_DATA [256] = 
{71, 308, 539, 772, 1003, 1235, 1467, 1701, 1929, 2162, 2392, 2624, 2852, 3085, 3316, 3548, 3776, 4006, 4236, 4466, 4696, 4927, 5156, 5384, 5613, 5843, 6072, 6301, 6530, 6758, 6987, 7214, 7444, 7672, 7899, 8126, 8355, 8581, 8809, 9036, 9262, 9489, 9714, 9943, 10169, 10405, 10638, 10865, 11093, 11319, 11544, 11769, 11997, 12223, 12448, 12674, 12900, 13124, 13350, 13577, 13802, 14025, 14251, 14476, 14700, 14924, 15147, 15373, 15598, 15820, 16044, 16269, 16493, 16716, 16938, 17163, 17386, 17608, 17829, 18054, 18276, 18498, 18721, 18943, 19165, 19386, 19608, 19831, 20051, 20272, 20494, 20715, 20936, 21157, 21379, 21676, 21148, 25310, -8267, -18330, -15837, -15989, -15763, -15535, -15306, -15076, -14842, -14612, -14378, -14143, -13909, -13676, -13440, -13205, -12968, -12733, -12496, -12260, -12024, -11786, -11550, -11312, -11074, -10838, -10599, -10362, -10125, -9889, -9650, -9415, -9177, -8940, -8704, -8467, -8229, -7992, -7753, -7521, -7284, -7046, -6808, -6573, -6338, -6100, -5864, -5629, -5392, -5156, -4923, -4687, -4451, -4215, -3981, -3746, -3511, -3276, -3042, -2807, -2571, -2337, -2103, -1869, -1634, -1400, -1168, -934, -699, -466, -234, -2, 232, 465, 698, 931, 1163, 1394, 1627, 1859, 2092, 2323, 2554, 2787, 3018, 3248, 3574, 2770, 7673, -566, -18242, -15249, -15505, -15270, -15034, -14800, -14562, -14326, -14090, -13853, -13616, -13379, -13141, -12902, -12667, -12429, -12191, -11952, -11713, -11475, -11238, -11000, -10761, -10525, -10284, -10046, -9810, -9572, -9334, -9097, -8860, -8622, -8383, -8146, -7909, -7673, -7435, -7197, -6961, -6724, -6488, -6252, -6015, -5780, -5543, -5307, -5073, -4837, -4601, -4367, -4131, -3895, -3661, -3426, -3191, -2957, -2721, -2489, -2256, -2020, -1786, -1553, -1319, -1086, -853, -621, -388, -150};