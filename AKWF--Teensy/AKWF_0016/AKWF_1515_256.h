/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1515 256 samples */
 
const int16_t AKWF_1515_256_DATA [256] = 
{1233, 3804, 6306, 8781, 11200, 13554, 15830, 18008, 20091, 22061, 23895, 25587, 27122, 28488, 29679, 30688, 31511, 32141, 32559, 32753, 32715, 32440, 31992, 31347, 30549, 29572, 28411, 27084, 25612, 24017, 22326, 20531, 18635, 16664, 14651, 12625, 10612, 8609, 6623, 4682, 2808, 1027, -669, -2266, -3781, -5153, -6388, -7489, -8472, -9357, -10144, -10813, -11378, -11833, -12178, -12418, -12555, -12593, -12541, -12404, -12184, -11886, -11516, -11078, -10580, -10031, -9438, -8809, -8155, -7481, -6795, -6109, -5433, -4776, -4151, -3561, -3017, -2527, -2104, -1754, -1484, -1309, -1247, -1307, -1502, -1792, -2208, -2736, -3399, -4183, -5073, -6044, -7077, -8172, -9309, -10473, -11648, -12809, -13946, -15048, -16090, -17055, -17913, -18641, -19231, -19689, -19998, -20148, -20123, -19953, -19616, -19193, -18628, -17937, -17138, -16235, -15238, -14157, -13003, -11784, -10516, -9208, -7858, -6476, -5063, -3624, -2178, -727, 726, 2177, 3623, 5062, 6475, 7857, 9208, 10515, 11783, 13003, 14157, 15238, 16235, 17138, 17936, 18628, 19192, 19616, 19953, 20123, 20148, 19998, 19688, 19231, 18641, 17912, 17055, 16090, 15047, 13945, 12809, 11648, 10472, 9308, 8171, 7077, 6043, 5072, 4183, 3398, 2735, 2207, 1791, 1501, 1306, 1246, 1308, 1483, 1753, 2103, 2526, 3016, 3560, 4150, 4775, 5432, 6109, 6794, 7480, 8154, 8809, 9437, 10030, 10579, 11077, 11515, 11886, 12183, 12403, 12540, 12592, 12554, 12417, 12177, 11832, 11377, 10812, 10143, 9356, 8472, 7488, 6388, 5152, 3780, 2265, 668, -1028, -2809, -4683, -6624, -8610, -10612, -12625, -14651, -16664, -18635, -20531, -22326, -24018, -25612, -27084, -28412, -29572, -30549, -31347, -31992, -32440, -32715, -32753, -32559, -32142, -31511, -30688, -29680, -28488, -27122, -25587, -23896, -22061, -20091, -18008, -15830, -13554, -11201, -8782, -6307, -3805, -1234};