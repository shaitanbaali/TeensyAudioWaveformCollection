/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1592 256 samples */
 
const int16_t AKWF_1592_256_DATA [256] = 
{310, 927, 1707, 2546, 3389, 4299, 5310, 6211, 6377, 5864, 6973, 9690, 12067, 13801, 15144, 16269, 17387, 18540, 19642, 20601, 21336, 21340, 21342, 22172, 22526, 22345, 22107, 21784, 21403, 20969, 20451, 19838, 19127, 18348, 17522, 16728, 15412, 13219, 12731, 13135, 12680, 11962, 11240, 10574, 10121, 9921, 10236, 11920, 13292, 13198, 13515, 14384, 15428, 16608, 17706, 18543, 19021, 19071, 18701, 17987, 17110, 16835, 18418, 21442, 24321, 26276, 27265, 27514, 27369, 27117, 26902, 26787, 26809, 27018, 27286, 27199, 26541, 25478, 24283, 23208, 22463, 22190, 22452, 23251, 24429, 25056, 25763, 26960, 26123, 23950, 22003, 18814, 16332, 17189, 17604, 16947, 16224, 15499, 14981, 14727, 14601, 14508, 14396, 14265, 14114, 13943, 13765, 13567, 13333, 13066, 12770, 12453, 12113, 11712, 11240, 10713, 10111, 9434, 8710, 7916, 7008, 5977, 4836, 3606, 2289, 715, -1523, -3633, -4470, -4503, -4500, -4574, -4353, -4474, -5374, -6073, -5463, -4141, -4873, -5869, -5908, -5789, -5658, -5580, -5648, -5807, -6014, -6199, -6395, -10048, -13579, -11096, -10087, -11258, -12154, -13040, -13736, -14160, -14531, -14885, -15215, -15512, -15749, -15940, -16109, -16283, -16500, -16916, -17725, -18731, -19660, -20454, -21084, -21517, -21784, -21962, -22123, -22318, -22548, -22787, -23036, -23292, -23547, -23821, -24124, -24472, -24888, -25367, -25898, -26443, -26918, -27182, -27041, -26294, -24804, -22787, -20875, -20552, -23870, -28838, -31914, -32774, -32203, -30934, -29699, -28833, -28202, -27069, -24594, -20840, -16696, -13207, -11136, -10685, -11379, -11667, -9626, -6106, -3470, -2567, -3098, -3981, -3699, -4436, -6495, -7690, -8417, -9102, -9725, -10413, -11109, -11617, -11852, -11920, -11972, -12027, -12018, -11914, -11720, -11443, -11120, -10774, -10401, -9975, -9486, -8954, -8390, -7792, -7159, -6469, -5682, -4555, -2725, -1113, -454, -114};