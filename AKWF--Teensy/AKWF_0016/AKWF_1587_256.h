/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1587 256 samples */
 
const int16_t AKWF_1587_256_DATA [256] = 
{11592, 21960, 22254, 25927, 29834, 32447, 32519, 30286, 27069, 24495, 23511, 23915, 24753, 25006, 24198, 22590, 20914, 19807, 19495, 19707, 19932, 19765, 19127, 18255, 17486, 17067, 17008, 17114, 17142, 16942, 16549, 16104, 15769, 15620, 15597, 15605, 15541, 15360, 15106, 14861, 14684, 14588, 14537, 14473, 14361, 14197, 14017, 13848, 13714, 13615, 13526, 13418, 13291, 13143, 12987, 12849, 12719, 12605, 12494, 12366, 12231, 12090, 11945, 11804, 11677, 11555, 11425, 11287, 11149, 11005, 10869, 10735, 10600, 10465, 10332, 10194, 10053, 9911, 9771, 9635, 9499, 9363, 9226, 9083, 8943, 8800, 8664, 8527, 8384, 8243, 8104, 7962, 7823, 7683, 7541, 7405, 7266, 7125, 6986, 6849, 6712, 6569, 6426, 6287, 6149, 6011, 5872, 5729, 5596, 5456, 5315, 5173, 5040, 4901, 4763, 4626, 4487, 4352, 4214, 4051, 3759, 4659, -13675, -24297, -23526, -24369, -24862, -25276, -25618, -25892, -26095, -26244, -26347, -26392, -26391, -26345, -26267, -26156, -26018, -25837, -25621, -25391, -25140, -24867, -24578, -24274, -23952, -23620, -23276, -22921, -22561, -22191, -21811, -21435, -21049, -20658, -20264, -19873, -19487, -19085, -18696, -18302, -17915, -17525, -17144, -16763, -16381, -16002, -15631, -15261, -14898, -14546, -14188, -13840, -13496, -13155, -12823, -12498, -12176, -11868, -11554, -11244, -10943, -10654, -10363, -10080, -9807, -9536, -9272, -9014, -8763, -8519, -8276, -8039, -7816, -7590, -7376, -7165, -6960, -6759, -6570, -6383, -6211, -6027, -5853, -5688, -5527, -5375, -5222, -5067, -4922, -4794, -4655, -4529, -4405, -4284, -4168, -4061, -3959, -3855, -3760, -3669, -3576, -3493, -3414, -3335, -3261, -3191, -3130, -3066, -3001, -2948, -2900, -2852, -2806, -2766, -2728, -2693, -2662, -2641, -2613, -2588, -2576, -2557, -2538, -2526, -2518, -2514, -2509, -2503, -2503, -2512, -2514, -2554, -2429, -2969};