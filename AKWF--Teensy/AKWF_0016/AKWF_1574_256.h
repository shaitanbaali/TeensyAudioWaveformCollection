/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1574 256 samples */
 
const int16_t AKWF_1574_256_DATA [256] = 
{5142, 5958, 5519, 5378, 5184, 5000, 4810, 4625, 4444, 4257, 4079, 3896, 3717, 3540, 3363, 3187, 3017, 2842, 2674, 2504, 2333, 2171, 2054, 1898, 1431, 19792, 33611, 31652, 31343, 30848, 30332, 29824, 29320, 28817, 28324, 27830, 27341, 26858, 26375, 25902, 25432, 24960, 24500, 24039, 23584, 23138, 22687, 22246, 21799, 21181, 21762, 10873, -6968, -7558, -7424, -7611, -7704, -7794, -7888, -7977, -8068, -8157, -8244, -8332, -8417, -8502, -8587, -8669, -8752, -8833, -8912, -8991, -9087, -8709, -11097, 2175, 16032, 13649, 14028, 13936, 13861, 13789, 13715, 13642, 13569, 13498, 13428, 13357, 13288, 13217, 13147, 13080, 13012, 12945, 12880, 12810, 12744, 12679, 12615, 12551, 12486, 12425, 12362, 12299, 12238, 12177, 12118, 12058, 12000, 11942, 11883, 11826, 11770, 11713, 11658, 11604, 11549, 11496, 11442, 11388, 11336, 11285, 11234, 11182, 11131, 11080, 11030, 10982, 10933, 10887, 10838, 10791, 10745, 10698, 10652, 10607, 10562, 10517, 10474, 10428, 10389, 10345, 10304, 10269, 10075, 10633, 7462, -14102, -21997, -20297, -20244, -19920, -19597, -19283, -18966, -18652, -18345, -18034, -17731, -17432, -17131, -16833, -16539, -16245, -15959, -15672, -15384, -15104, -14823, -14547, -14272, -13999, -13729, -13461, -13195, -12935, -12672, -12412, -12154, -11901, -11651, -11401, -11153, -10907, -10662, -10423, -10185, -9947, -9712, -9477, -9248, -9019, -8793, -8570, -8347, -8126, -7909, -7692, -7479, -7268, -7056, -6847, -6643, -6437, -6234, -6034, -5835, -5640, -5443, -5249, -5058, -4865, -4679, -4490, -4311, -4123, -3942, -3764, -3587, -3409, -3231, -3065, -2884, -2720, -2546, -2396, -2213, -2056, -2255, -190, -17118, -26589, -24413, -24654, -24484, -24349, -24182, -24035, -23889, -23738, -23586, -23440, -23298, -23149, -23008, -22862, -22727, -22583, -22442, -22307, -22167, -22032, -21884, -21600, -22340, -11893};