/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1596 256 samples */
 
const int16_t AKWF_1596_256_DATA [256] = 
{3, 28, 78, 159, 275, 430, 629, 871, 1165, 1524, 1942, 2424, 2968, 3568, 4230, 4951, 5722, 6547, 7421, 8336, 9294, 10287, 11308, 12360, 13432, 14516, 15614, 16714, 17812, 18908, 19987, 21049, 22089, 23097, 24071, 25008, 25900, 26740, 27531, 28263, 28936, 29546, 30087, 30562, 30968, 31298, 31574, 31829, 32063, 32269, 32445, 32585, 32687, 32750, 32768, 32743, 32669, 32550, 32384, 32166, 31904, 31594, 31239, 30836, 30390, 29901, 29373, 28809, 28209, 27578, 26915, 26231, 25521, 24794, 24052, 23303, 22544, 21786, 21029, 20279, 19540, 18818, 18115, 17433, 16764, 16113, 15482, 14876, 14298, 13750, 13231, 12749, 12303, 11895, 11529, 11206, 10922, 10687, 10467, 10235, 9993, 9743, 9484, 9218, 8943, 8656, 8360, 8051, 7732, 7404, 7062, 6708, 6349, 5977, 5593, 5203, 4804, 4396, 3982, 3562, 3133, 2700, 2263, 1823, 1378, 930, 481, 33, -416, -865, -1313, -1759, -2200, -2636, -3071, -3500, -3922, -4337, -4746, -5145, -5537, -5922, -6295, -6657, -7011, -7355, -7686, -8006, -8316, -8614, -8902, -9180, -9446, -9706, -9958, -10201, -10434, -10655, -10885, -11162, -11480, -11839, -12241, -12683, -13158, -13672, -14217, -14790, -15392, -16020, -16667, -17334, -18015, -18713, -19433, -20172, -20918, -21675, -22435, -23192, -23942, -24687, -25415, -26128, -26817, -27482, -28119, -28724, -29292, -29826, -30322, -30773, -31183, -31545, -31861, -32130, -32355, -32529, -32654, -32735, -32767, -32755, -32699, -32602, -32468, -32297, -32095, -31865, -31613, -31342, -31021, -30627, -30161, -29629, -29030, -28365, -27642, -26860, -26026, -25141, -24212, -23242, -22239, -21205, -20143, -19067, -17975, -16874, -15776, -14678, -13590, -12517, -11463, -10434, -9439, -8475, -7552, -6673, -5842, -5060, -4334, -3663, -3053, -2502, -2010, -1582, -1215, -911, -663, -458, -296, -175, -89, -35, -7, 0};