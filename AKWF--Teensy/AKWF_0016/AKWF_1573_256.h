/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1573 256 samples */
 
const int16_t AKWF_1573_256_DATA [256] = 
{4807, 5728, 5277, 5142, 4948, 4763, 4573, 4388, 4206, 4021, 3839, 3660, 3479, 3302, 3127, 2952, 2778, 2605, 2433, 2266, 2098, 1931, 1766, 1597, 1437, 1277, 1304, 347, 4436, 27083, 32953, 31221, 30959, 30439, 29921, 29413, 28911, 28409, 27911, 27421, 26931, 26447, 25969, 25494, 25022, 24557, 24095, 23637, 23181, 22537, 23065, 15039, -4664, -7112, -6637, -6891, -6995, -7089, -7193, -7293, -7390, -7489, -7582, -7680, -7773, -7867, -7960, -8049, -8140, -8230, -8317, -8406, -8492, -8576, -8663, -8746, -8828, -8911, -8991, -9071, -9151, -9228, -9308, -9394, -9102, -11097, 6422, 15872, 13870, 14154, 14077, 14004, 13932, 13859, 13789, 13717, 13647, 13577, 13507, 13437, 13367, 13299, 13232, 13163, 13096, 13031, 12965, 12902, 12836, 12770, 12708, 12646, 12583, 12521, 12460, 12401, 12340, 12281, 12225, 12165, 12106, 12049, 11994, 11939, 11881, 11827, 11772, 11718, 11665, 11611, 11558, 11508, 11456, 11403, 11354, 11303, 11254, 11203, 11155, 11108, 11058, 11012, 10966, 10918, 10878, 10830, 10788, 10747, 10503, 11349, 5863, -16839, -21790, -20399, -20301, -19977, -19650, -19331, -19012, -18693, -18386, -18073, -17765, -17461, -17156, -16857, -16559, -16265, -15972, -15681, -15392, -15109, -14827, -14549, -14269, -13993, -13722, -13450, -13182, -12916, -12651, -12390, -12132, -11874, -11620, -11367, -11117, -10869, -10623, -10379, -10136, -9897, -9661, -9425, -9193, -8961, -8731, -8508, -8282, -8059, -7839, -7619, -7405, -7190, -6977, -6769, -6558, -6351, -6148, -5946, -5743, -5544, -5346, -5150, -4959, -4767, -4577, -4384, -4200, -4014, -3833, -3647, -3469, -3293, -3112, -2940, -2766, -2599, -2422, -2259, -2092, -1931, -1762, -1602, -1449, -1276, -1126, -964, -829, -1035, 1241, -14387, -25991, -23611, -23918, -23740, -23608, -23461, -23320, -23170, -23034, -22888, -22754, -22445, -23161, -18654};