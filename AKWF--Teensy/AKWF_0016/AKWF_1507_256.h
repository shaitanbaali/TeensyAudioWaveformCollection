/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1507 256 samples */
 
const int16_t AKWF_1507_256_DATA [256] = 
{470, 1209, 1828, 2419, 2976, 3517, 4037, 4543, 5046, 5542, 6017, 6485, 6950, 7409, 7861, 8308, 8747, 9185, 9618, 10041, 10459, 10884, 11303, 11699, 12106, 12519, 12912, 13308, 13697, 14084, 14471, 14855, 15231, 15605, 15969, 16340, 16700, 17063, 17421, 17768, 18123, 18464, 18810, 19160, 19492, 19827, 20151, 20481, 20805, 21126, 21441, 21758, 22057, 22372, 22675, 22973, 23268, 23561, 23846, 24134, 24421, 24692, 24972, 25243, 25507, 25772, 26035, 26291, 26535, 26793, 27038, 27269, 27513, 27750, 27981, 28204, 28430, 28647, 28860, 29071, 29281, 29481, 29685, 29880, 30072, 30260, 30435, 30618, 30792, 30965, 31126, 31292, 31453, 31609, 31755, 31905, 32048, 32183, 32312, 32441, 32550, 32652, 32729, 32762, 32746, 32654, 32455, 32114, 31597, 30898, 30075, 29183, 28577, 28270, 21632, 4589, 39, 772, 548, 487, 434, 380, 320, 263, 204, 148, 92, 29, -30, -93, -149, -205, -264, -321, -381, -435, -488, -549, -773, -40, -4590, -21633, -28270, -28577, -29183, -30075, -30898, -31597, -32114, -32455, -32654, -32746, -32762, -32729, -32652, -32550, -32441, -32312, -32183, -32048, -31905, -31755, -31609, -31453, -31292, -31126, -30965, -30792, -30618, -30435, -30260, -30072, -29880, -29685, -29482, -29281, -29071, -28860, -28648, -28431, -28204, -27981, -27750, -27513, -27269, -27038, -26794, -26535, -26291, -26035, -25772, -25507, -25243, -24973, -24692, -24421, -24134, -23847, -23561, -23268, -22973, -22675, -22372, -22058, -21758, -21441, -21126, -20806, -20482, -20152, -19827, -19492, -19160, -18811, -18465, -18124, -17769, -17421, -17064, -16700, -16341, -15970, -15605, -15232, -14856, -14472, -14085, -13697, -13309, -12912, -12520, -12107, -11699, -11303, -10885, -10460, -10041, -9619, -9185, -8748, -8308, -7862, -7410, -6951, -6486, -6018, -5543, -5047, -4544, -4038, -3518, -2977, -2420, -1829, -1210, -471};