/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1567 256 samples */
 
const int16_t AKWF_1567_256_DATA [256] = 
{205, 481, 722, 951, 1170, 1384, 1601, 1818, 2035, 2245, 2434, 2625, 2804, 2977, 3152, 3324, 3485, 3641, 3786, 3937, 4075, 4211, 4343, 4471, 4596, 4721, 4834, 4936, 5046, 5143, 5241, 5334, 5424, 5503, 5579, 5655, 5724, 5792, 5857, 5916, 5969, 6024, 6073, 6116, 6153, 6195, 6235, 6262, 6287, 6313, 6335, 6351, 6366, 6381, 6387, 6386, 6394, 6393, 6385, 6385, 6380, 6373, 6358, 6344, 6327, 6307, 6287, 6263, 6237, 6208, 6181, 6144, 6109, 6070, 6028, 5989, 5946, 5898, 5852, 5804, 5756, 5699, 5646, 5590, 5535, 5475, 5418, 5353, 5293, 5226, 5160, 5092, 5020, 4950, 4876, 4806, 4735, 4654, 4577, 4500, 4425, 4345, 4262, 4179, 4092, 4015, 3928, 3839, 3755, 3666, 3577, 3487, 3396, 3303, 3212, 3119, 3024, 2930, 2835, 2741, 2642, 2543, 2447, 2346, 2249, 2154, 2050, 1953, 1850, 1745, 1646, 1541, 1437, 1338, 1233, 1124, 1018, 914, 807, 700, 590, 483, 376, 271, 161, 51, -56, -162, -272, -387, -496, -607, -715, -823, -934, -1049, -1159, -1274, -1384, -1492, -1607, -1723, -1833, -1948, -2059, -2170, -2285, -2393, -2506, -2620, -2730, -2841, -2952, -3067, -3181, -3293, -3405, -3516, -3628, -3745, -3852, -3963, -4078, -4191, -4301, -4413, -4524, -4635, -4748, -4857, -4970, -5082, -5459, -4116, -20243, -32077, -31075, -32818, -28320, -11686, -10175, -8069, -4499, -1263, 15, -1163, -3937, -6763, -8337, -8339, -7406, -6573, -6605, -7574, -8936, -9974, -10265, -9871, -9222, -8798, -8821, -9191, -9589, -9713, -9457, -8955, -8429, -8068, -7921, -7887, -7809, -7560, -7160, -6685, -6257, -5925, -5694, -5484, -5225, -4893, -4502, -4105, -3753, -3462, -3195, -2937, -2649, -2329, -2001, -1683, -1394, -1137, -884, -629, -366, -96};