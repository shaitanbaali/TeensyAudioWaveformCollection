/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1528 256 samples */
 
const int16_t AKWF_1528_256_DATA [256] = 
{1315, 3441, 5333, 6931, 8182, 9122, 9835, 10396, 10794, 10965, 10881, 10571, 10130, 9677, 9257, 8807, 8244, 7561, 6829, 6162, 5670, 5394, 5260, 5145, 4985, 4801, 4672, 4714, 5004, 5524, 6169, 6847, 7526, 8213, 8959, 9854, 10969, 12312, 13823, 15426, 17088, 18784, 20507, 22296, 24203, 26317, 28234, 29037, 28953, 28536, 28029, 27503, 26981, 26469, 25966, 25472, 24988, 24514, 24047, 23590, 23141, 22701, 22269, 21846, 21430, 21023, 20623, 20230, 19846, 19469, 19098, 18737, 18380, 18030, 17688, 17351, 17020, 16698, 16380, 16068, 15762, 15462, 15169, 14880, 14598, 14319, 14047, 13781, 13518, 13261, 13009, 12761, 12520, 12281, 12047, 11818, 11594, 11373, 11158, 10945, 10737, 10532, 10332, 10136, 9943, 9753, 9569, 9387, 9207, 9033, 8862, 8694, 8528, 8364, 8206, 8050, 7897, 7748, 7599, 7451, 7318, 6933, 5996, 4779, 3574, 2493, 1593, 904, 448, 238, 259, 491, 907, 1488, 2222, 3089, 4081, 5132, 5843, 6071, 6062, 5975, 5868, 5759, 5649, 5541, 5437, 5334, 5231, 5132, 5035, 4938, 4841, 4756, 4607, 3893, 2491, 709, -1258, -3335, -5477, -7635, -9776, -11873, -13896, -15827, -17659, -19364, -20926, -22328, -23547, -24575, -25396, -26000, -26404, -26630, -26700, -26641, -26467, -26176, -27086, -29757, -32052, -32765, -32567, -32065, -31484, -30891, -30307, -29730, -29164, -28611, -28065, -27532, -27009, -26495, -25992, -25498, -25012, -24537, -24071, -23612, -23164, -22723, -22292, -21867, -21451, -21044, -20644, -20251, -19865, -19488, -19117, -18754, -18398, -18047, -17704, -17368, -17039, -16714, -16396, -16084, -15778, -15478, -15185, -14895, -14611, -14333, -14062, -13794, -13532, -13276, -13024, -12776, -12531, -12293, -12060, -11830, -11606, -11385, -11169, -10956, -10748, -10543, -10343, -10147, -9954, -9763, -9578, -9390, -9229, -8905, -7607, -5461, -3128, -815};