/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1504 256 samples */
 
const int16_t AKWF_1504_256_DATA [256] = 
{3689, 10398, 13115, 14912, 16511, 17891, 19130, 20256, 21296, 22266, 23175, 24034, 24849, 25625, 26369, 27082, 27767, 28430, 29069, 29686, 30287, 30868, 31433, 31981, 32538, 32784, 32762, 32767, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32590, 32850, 32301, -16109, -35815, -32040, -32775, -32719, -32258, -31700, -31145, -30572, -29980, -29371, -28743, -28092, -27419, -26720, -25991, -25231, -24435, -23598, -22715, -21775, -20771, -19690, -18508, -17202, -15729, -13971, -12045, -7380, 108, 7584, 12118, 14026, 15774, 17242, 18545, 19720, 20801, 21804, 22739, 23623, 24459, 25253, 26013, 26740, 27437, 28110, 28761, 29387, 29998, 30589, 31160, 31715, 32275, 32725, 32774, 32765, 32768, 32768, 32768, 32768, 32267, 34475, 23133, -23134, -34475, -32267, -32767, -32767, -32767, -32767, -32765, -32774, -32725, -32275, -31715, -31160, -30589, -29998, -29387, -28761, -28111, -27437, -26740, -26013, -25253, -24459, -23623, -22740, -21804, -20801, -19721, -18545, -17242, -15774, -14026, -12118, -7584, -109, 7379, 12044, 13970, 15729, 17202, 18508, 19690, 20771, 21775, 22714, 23598, 24434, 25231, 25991, 26720, 27418, 28092, 28743, 29370, 29980, 30572, 31145, 31700, 32258, 32719, 32775, 32040, 35815, 16109, -32302, -32850, -32590, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32762, -32784, -32538, -31981, -31433, -30868, -30287, -29686, -29069, -28430, -27767, -27082, -26370, -25626, -24849, -24034, -23176, -22266, -21296, -20257, -19131, -17892, -16512, -14913, -13115, -10398, -3690};