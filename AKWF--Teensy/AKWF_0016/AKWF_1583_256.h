/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1583 256 samples */
 
const int16_t AKWF_1583_256_DATA [256] = 
{12826, 21651, 22535, 26405, 32663, 16818, 1029, -792, -5501, -8847, -10203, -9930, -9229, -9260, -10463, -12457, -14349, -15434, -15548, -15080, -14644, -14678, -15199, -15892, -16370, -16389, -15985, -15424, -14982, -14784, -14779, -14779, -14612, -14228, -13690, -13138, -12690, -12362, -12092, -11791, -11403, -10931, -10403, -9913, -9480, -9109, -8746, -8367, -7942, -7482, -7022, -6592, -6195, -5825, -5465, -5081, -4687, -4287, -3896, -3529, -3185, -2845, -2517, -2176, -1832, -1493, -1175, -859, -559, -275, 40, 367, 640, 917, 1183, 1441, 1691, 1925, 2159, 2389, 2613, 2829, 3039, 3235, 3424, 3602, 3793, 3970, 4140, 4304, 4459, 4615, 4770, 4912, 5039, 5178, 5301, 5423, 5539, 5650, 5749, 5845, 5941, 6029, 6114, 6197, 6269, 6337, 6406, 6469, 6526, 6571, 6627, 6678, 6714, 6747, 6781, 6811, 6834, 6854, 6872, 6882, 6883, 6895, 6899, 6889, 6893, 6888, 6882, 6867, 6849, 6832, 6810, 6787, 6758, 6729, 6695, 6663, 6621, 6580, 6532, 6486, 6440, 6390, 6333, 6278, 6222, 6166, 6099, 6035, 5969, 5902, 5830, 5763, 5685, 5614, 5536, 5455, 5377, 5290, 5205, 5114, 5031, 4947, 4850, 4756, 4664, 4575, 4477, 4378, 4279, 4175, 4081, 3976, 3869, 3770, 3661, 3553, 3445, 3335, 3223, 3115, 3004, 2888, 2775, 2660, 2546, 2428, 2310, 2193, 2071, 1952, 1839, 1713, 1596, 1470, 1343, 1225, 1097, 972, 854, 726, 592, 467, 343, 213, 83, -49, -178, -306, -435, -568, -700, -834, -962, -1093, -1231, -1363, -1497, -1629, -1761, -1896, -2032, -2167, -2303, -2438, -2570, -2709, -2849, -2982, -3122, -3256, -3388, -3529, -3660, -3795, -3933, -4069, -4203, -4335, -4475, -4613, -4751, -4887, -5021, -5155, -5296, -5427, -5562, -5696, -5839, -5971, -6107, -6239, -6346, -6717};