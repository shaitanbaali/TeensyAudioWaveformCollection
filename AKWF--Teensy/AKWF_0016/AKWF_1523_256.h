/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1523 256 samples */
 
const int16_t AKWF_1523_256_DATA [256] = 
{150, 464, 773, 1084, 1391, 1702, 2009, 2320, 2629, 2938, 3250, 3557, 3871, 4175, 4489, 4799, 5104, 5425, 5719, 6040, 6386, 6541, 7359, 11583, 15195, 18909, 22552, 26176, 30104, 32744, 32335, 32245, 32075, 31937, 31778, 31627, 31474, 31319, 31164, 31011, 30858, 30702, 30549, 30394, 30241, 30087, 29932, 29778, 29622, 29469, 29314, 29160, 29007, 28850, 28699, 28542, 28391, 28235, 28078, 27932, 27771, 27622, 27467, 27314, 27164, 27007, 26858, 26701, 26551, 26400, 26241, 26098, 25938, 25791, 25639, 25483, 25338, 25178, 25037, 24880, 24730, 24585, 24423, 24285, 24123, 23981, 23831, 23671, 23539, 23370, 23236, 23083, 22919, 22804, 22611, 22473, 22431, 21903, 18522, 18267, 17924, 17652, 17291, 16993, 16679, 16345, 16052, 15718, 15408, 15096, 14771, 14456, 14166, 13719, 12736, 11800, 10858, 9907, 8972, 8020, 7078, 6138, 5188, 4251, 3303, 2359, 1417, 469, -470, -1418, -2360, -3304, -4251, -5188, -6139, -7078, -8021, -8973, -9907, -10858, -11800, -12736, -13719, -14166, -14456, -14771, -15096, -15409, -15718, -16053, -16346, -16679, -16993, -17291, -17652, -17925, -18267, -18523, -21903, -22431, -22473, -22611, -22805, -22919, -23083, -23237, -23371, -23539, -23672, -23831, -23981, -24123, -24285, -24423, -24585, -24730, -24881, -25038, -25178, -25338, -25483, -25639, -25791, -25939, -26098, -26241, -26400, -26552, -26701, -26858, -27007, -27164, -27314, -27467, -27622, -27771, -27932, -28079, -28235, -28391, -28542, -28699, -28850, -29007, -29160, -29314, -29469, -29622, -29778, -29932, -30087, -30241, -30394, -30549, -30702, -30858, -31011, -31164, -31319, -31474, -31627, -31778, -31937, -32075, -32245, -32335, -32744, -30104, -26176, -22553, -18909, -15196, -11584, -7360, -6541, -6387, -6041, -5720, -5425, -5104, -4800, -4489, -4176, -3872, -3558, -3251, -2939, -2630, -2321, -2010, -1703, -1392, -1084, -774, -465, -151};