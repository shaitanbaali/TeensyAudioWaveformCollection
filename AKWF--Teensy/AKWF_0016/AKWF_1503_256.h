/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1503 256 samples */
 
const int16_t AKWF_1503_256_DATA [256] = 
{990, 3070, 5095, 7086, 8810, 9954, 10870, 11728, 12558, 13384, 14219, 15073, 15952, 16851, 17776, 18732, 19732, 20780, 21864, 22982, 24128, 25283, 26430, 27565, 28670, 29741, 30765, 31434, 31740, 31949, 32119, 32269, 32395, 32504, 32594, 32667, 32718, 32752, 32767, 32765, 32748, 32715, 32670, 32613, 32549, 32481, 32411, 32343, 32279, 32224, 32180, 32149, 32136, 32140, 32163, 32210, 32277, 32372, 32446, 32311, 32052, 31786, 31530, 31291, 31070, 30865, 30677, 30504, 30345, 30196, 30059, 29929, 29805, 29685, 29566, 29447, 29325, 29198, 29062, 28917, 28761, 28586, 28390, 28172, 27927, 27649, 27341, 26996, 26613, 26190, 25726, 25221, 24670, 24078, 23445, 22771, 22059, 21306, 20519, 19452, 17925, 16248, 14544, 12840, 11218, 10027, 9118, 8277, 7458, 6643, 5821, 4992, 4166, 3342, 2540, 1782, 1087, 481, -3, -345, -547, -638, -610, -507, -399, -289, -174, -58, 57, 173, 288, 398, 506, 609, 637, 546, 344, 2, -482, -1088, -1783, -2541, -3343, -4167, -4993, -5822, -6644, -7458, -8278, -9119, -10028, -11218, -12840, -14544, -16249, -17926, -19453, -20520, -21306, -22059, -22772, -23445, -24078, -24671, -25221, -25727, -26190, -26613, -26996, -27341, -27649, -27927, -28172, -28390, -28586, -28761, -28917, -29063, -29198, -29325, -29447, -29566, -29685, -29805, -29929, -30059, -30196, -30345, -30504, -30677, -30865, -31070, -31291, -31530, -31786, -32052, -32311, -32446, -32372, -32277, -32210, -32163, -32140, -32136, -32149, -32180, -32225, -32279, -32343, -32411, -32481, -32549, -32613, -32670, -32715, -32748, -32765, -32767, -32752, -32718, -32667, -32594, -32504, -32395, -32269, -32119, -31949, -31740, -31434, -30765, -29741, -28670, -27566, -26431, -25283, -24128, -22982, -21864, -20781, -19732, -18733, -17777, -16851, -15952, -15073, -14219, -13385, -12559, -11729, -10870, -9955, -8811, -7087, -5096, -3071, -991};