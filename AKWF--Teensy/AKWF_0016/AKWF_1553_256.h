/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1553 256 samples */
 
const int16_t AKWF_1553_256_DATA [256] = 
{434, 1288, 1965, 2532, 2999, 3384, 3701, 3962, 4178, 4356, 4502, 4623, 4721, 4801, 4869, 4923, 4967, 5003, 5032, 5056, 5074, 5090, 5102, 5111, 5118, 5124, 5127, 5129, 5131, 5131, 5131, 5131, 5129, 5128, 5125, 5124, 5122, 5119, 5116, 5113, 5112, 5107, 5105, 5101, 5098, 5095, 5091, 5088, 5084, 5080, 5077, 5074, 5070, 5066, 5063, 5060, 5056, 5053, 5049, 5045, 5042, 5038, 5035, 5032, 5027, 5023, 5021, 5017, 5013, 5011, 5008, 5003, 4999, 4996, 4993, 4990, 4985, 4982, 4978, 4975, 4980, 4429, 7342, -11446, -34711, -32348, -32742, -32761, -32755, -32747, -32738, -32729, -32719, -32709, -32697, -32684, -32671, -32658, -32643, -32629, -32614, -32599, -32582, -32566, -32551, -32528, -31929, -35033, -10293, 7806, 4670, 5259, 5270, 5277, 5284, 5291, 5295, 5301, 5303, 5306, 5308, 5310, 5311, 5311, 5312, 5313, 5312, 5311, 5310, 5309, 5309, 5306, 5303, 5301, 5298, 5297, 5293, 5292, 5289, 5286, 5283, 5280, 5276, 5273, 5271, 5269, 5265, 5260, 5258, 5255, 5251, 5249, 5244, 5240, 5238, 5234, 5231, 5228, 5223, 5219, 5217, 5214, 5210, 5207, 5202, 5199, 5201, 4766, 7114, -4624, -28506, -21626, -17037, -13192, -9965, -7318, -5144, -3322, -1847, -484, 647, 1458, 2147, 2709, 3175, 3557, 3873, 4134, 4349, 4526, 4671, 4790, 4889, 4970, 5035, 5090, 5134, 5169, 5199, 5222, 5240, 5257, 5268, 5276, 5284, 5290, 5292, 5294, 5296, 5297, 5297, 5296, 5295, 5293, 5291, 5289, 5287, 5284, 5281, 5277, 5273, 5271, 5269, 5266, 5263, 5259, 5255, 5252, 5248, 5245, 5241, 5237, 5233, 5230, 5226, 5223, 5219, 5216, 5213, 5209, 5205, 5202, 5202, 4823, 6885, -3319, -27912, -21517, -16836, -13034, -9854, -7233, -5052, -3253, -1780, -545};