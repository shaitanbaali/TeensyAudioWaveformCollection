/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1589 256 samples */
 
const int16_t AKWF_1589_256_DATA [256] = 
{18252, 20410, 19048, 18418, 17689, 16969, 16231, 15521, 14808, 14095, 13390, 12687, 11989, 11293, 10601, 9912, 9228, 8546, 7866, 7192, 6521, 5850, 5187, 4522, 3864, 3209, 2553, 1904, 1259, 614, -27, -664, -1300, -1932, -2561, -3187, -3810, -4431, -5047, -5660, -6272, -6874, -7477, -8091, -8680, -9288, -9494, -12127, 263, 13575, 11329, 11417, 11191, 11035, 10877, 10718, 10560, 10404, 10248, 10090, 9934, 9779, 9624, 9470, 9316, 9162, 9010, 8856, 8705, 8553, 8402, 8251, 8100, 7951, 7801, 7652, 7504, 7357, 7209, 7061, 6915, 6769, 6624, 6479, 6334, 6190, 6047, 5904, 5762, 5621, 5479, 5338, 5199, 5059, 4921, 4781, 4643, 4506, 4369, 4233, 4097, 3962, 3827, 3694, 3561, 3427, 3296, 3164, 3033, 2902, 2773, 2643, 2515, 2386, 2260, 2134, 2006, 1882, 1757, 1633, 1509, 1387, 1265, 1143, 1023, 902, 783, 664, 546, 429, 311, 196, 81, -33, -146, -259, -372, -483, -594, -706, -815, -924, -1032, -1140, -1245, -1351, -1457, -1560, -1664, -1768, -1870, -1971, -2072, -2159, -2235, -2314, -2395, -2477, -2563, -2649, -2737, -2827, -2920, -3013, -3109, -3207, -3305, -3405, -3508, -3613, -3719, -3826, -3936, -4048, -4160, -4275, -4390, -4508, -4628, -4749, -4872, -4996, -5121, -5249, -5378, -5509, -5641, -5775, -5910, -6046, -6186, -6320, -6581, -6938, -7293, -7657, -8024, -8401, -8785, -9174, -9570, -9974, -10384, -10801, -11223, -11652, -12089, -12531, -12979, -13436, -13899, -14367, -14840, -15321, -15807, -16301, -16800, -17306, -17819, -18335, -18859, -19391, -19926, -20468, -21017, -21571, -22131, -22698, -23269, -23848, -24433, -25022, -25616, -26218, -26824, -27439, -28056, -28679, -29310, -29946, -30585, -31202, -31875, -32697, -20256, -17099, -19207, -20206, -21365, -22472, -23614, -24720, -25821, -26756, -28801, -25405};