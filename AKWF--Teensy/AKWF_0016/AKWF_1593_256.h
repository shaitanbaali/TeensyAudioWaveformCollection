/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1593 256 samples */
 
const int16_t AKWF_1593_256_DATA [256] = 
{540, 1660, 2733, 3768, 4750, 5680, 6570, 7433, 8281, 9121, 9950, 10784, 11623, 12465, 13316, 14179, 15054, 15949, 16854, 17742, 18625, 19526, 20439, 21351, 22251, 23140, 24021, 24886, 25731, 26554, 27345, 28095, 28790, 29411, 29957, 30435, 30851, 31212, 31525, 31791, 32011, 32186, 32321, 32426, 32505, 32568, 32618, 32659, 32693, 32720, 32743, 32759, 32767, 32768, 32758, 32725, 32663, 32568, 32437, 32272, 32077, 31852, 31602, 31330, 31037, 30730, 30410, 30081, 29750, 29420, 29091, 28773, 28462, 28157, 27854, 27544, 27224, 26896, 26557, 26208, 25851, 25485, 25106, 24720, 24328, 23932, 23533, 23133, 22730, 22319, 21890, 21436, 20951, 20422, 19844, 19206, 18512, 17778, 17021, 16250, 15475, 14703, 13939, 13196, 12479, 11793, 11144, 10536, 9966, 9403, 8825, 8255, 7703, 7163, 6628, 6099, 5570, 5046, 4530, 4027, 3550, 3101, 2670, 2233, 1776, 1292, 786, 263, -264, -787, -1293, -1777, -2234, -2671, -3102, -3551, -4028, -4531, -5047, -5571, -6100, -6629, -7164, -7704, -8256, -8826, -9404, -9967, -10536, -11145, -11794, -12480, -13196, -13940, -14704, -15476, -16251, -17021, -17778, -18512, -19206, -19844, -20423, -20951, -21436, -21890, -22319, -22730, -23133, -23533, -23932, -24328, -24721, -25107, -25485, -25851, -26208, -26558, -26896, -27224, -27544, -27854, -28157, -28462, -28773, -29091, -29420, -29750, -30081, -30410, -30730, -31037, -31330, -31602, -31852, -32077, -32272, -32437, -32568, -32663, -32725, -32758, -32768, -32767, -32759, -32743, -32720, -32693, -32659, -32618, -32568, -32505, -32426, -32321, -32186, -32011, -31791, -31525, -31212, -30851, -30435, -29957, -29411, -28790, -28096, -27345, -26554, -25731, -24886, -24022, -23140, -22251, -21351, -20440, -19526, -18625, -17743, -16854, -15950, -15054, -14180, -13316, -12466, -11624, -10785, -9951, -9121, -8282, -7434, -6570, -5681, -4750, -3769, -2734, -1661, -541};