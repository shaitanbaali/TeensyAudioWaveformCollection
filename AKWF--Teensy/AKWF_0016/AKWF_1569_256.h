/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1569 256 samples */
 
const int16_t AKWF_1569_256_DATA [256] = 
{8802, 18892, 18073, 18055, 17960, 17849, 17742, 17629, 17521, 17414, 17306, 17202, 17095, 16990, 16887, 16783, 16681, 16578, 16474, 16375, 16275, 16175, 16078, 15979, 15882, 15789, 15690, 15595, 15500, 15407, 15316, 15223, 15131, 15039, 14950, 14861, 14774, 14687, 14600, 14512, 14428, 14343, 14258, 14178, 14093, 14013, 13934, 13851, 13775, 13662, 13561, 13774, 2335, -8069, -7182, -7101, -6957, -6790, -6627, -6461, -6300, -6141, -5980, -5824, -5667, -5506, -5153, -6053, 3104, 18577, 18850, 18530, 18476, 18348, 18217, 18094, 17965, 17840, 17718, 17594, 17470, 17349, 17230, 17110, 16992, 16873, 16760, 16642, 16528, 16417, 16305, 16193, 16081, 15972, 15862, 15754, 15647, 15544, 15436, 15332, 15227, 15115, 14909, 15579, 838, -4115, -3109, -3418, -3513, -3608, -3700, -3791, -3882, -3973, -4063, -4147, -4237, -4323, -4407, -4491, -4574, -4658, -4736, -4816, -4896, -4977, -5052, -5131, -5205, -5283, -5357, -5431, -5506, -5579, -5651, -5721, -5793, -5862, -5932, -6000, -6069, -6137, -6203, -6269, -6334, -6399, -6462, -6527, -6590, -6652, -6713, -6774, -6834, -6894, -6951, -7011, -7068, -7125, -7183, -7238, -7294, -7349, -7401, -7456, -7509, -7562, -7616, -7667, -7718, -7770, -7819, -7870, -7920, -7968, -8018, -8065, -8113, -8160, -8205, -8251, -8297, -8341, -8387, -8429, -8471, -8516, -8554, -8636, -8683, -8466, -21753, -33230, -32079, -31957, -31742, -31505, -31272, -31041, -30811, -30583, -30360, -29826, -31236, -22533, -10168, -11618, -11089, -10882, -10672, -10464, -10259, -10056, -9853, -9653, -9456, -9261, -9066, -8872, -8683, -8492, -8306, -8121, -7935, -7754, -7574, -7395, -7218, -7042, -6870, -6697, -6525, -6357, -6189, -6022, -5859, -5694, -5535, -5376, -5217, -5060, -4903, -4749, -4598, -4446, -4295, -4146, -3997, -3854, -3709, -3564, -3423, -3279, -3143, -2989, -2919, -2404};