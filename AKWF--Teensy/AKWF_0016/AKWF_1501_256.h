/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1501 256 samples */
 
const int16_t AKWF_1501_256_DATA [256] = 
{150, 464, 772, 1082, 1389, 1699, 2009, 2317, 2625, 2936, 3244, 3553, 3863, 4172, 4480, 4789, 5099, 5408, 5717, 6026, 6336, 6643, 6953, 7263, 7572, 7879, 8189, 8499, 8808, 9117, 9426, 9735, 10045, 10353, 10662, 10972, 11280, 11589, 11898, 12207, 12516, 12827, 13134, 13443, 13753, 14062, 14371, 14681, 14990, 15298, 15607, 15917, 16226, 16534, 16843, 17153, 17461, 17770, 18080, 18388, 18697, 19007, 19316, 19623, 19933, 20242, 20551, 20860, 21167, 21476, 21786, 22094, 22402, 22711, 23018, 23327, 23635, 23941, 24249, 24557, 24863, 25170, 25476, 25781, 26086, 26390, 26694, 26996, 27298, 27598, 27896, 28195, 28489, 28783, 29073, 29359, 29645, 29923, 30199, 30468, 30732, 30987, 31235, 31471, 31696, 31908, 32103, 32281, 32437, 32568, 32670, 32739, 32768, 32754, 32685, 32555, 32354, 32071, 31692, 31191, 30520, 30080, 23731, 18453, 14682, 10694, 7151, 2558, -2559, -7152, -10694, -14683, -18454, -23731, -30080, -30520, -31191, -31692, -32071, -32354, -32555, -32685, -32754, -32768, -32739, -32670, -32568, -32437, -32281, -32103, -31908, -31696, -31471, -31235, -30987, -30732, -30468, -30199, -29924, -29645, -29359, -29073, -28783, -28490, -28195, -27896, -27598, -27298, -26996, -26694, -26390, -26086, -25781, -25476, -25170, -24863, -24557, -24249, -23941, -23636, -23327, -23018, -22711, -22402, -22095, -21786, -21477, -21168, -20860, -20551, -20242, -19933, -19624, -19316, -19007, -18697, -18388, -18080, -17770, -17462, -17153, -16843, -16534, -16226, -15917, -15608, -15299, -14990, -14681, -14371, -14063, -13754, -13444, -13135, -12827, -12516, -12208, -11899, -11590, -11281, -10973, -10663, -10354, -10045, -9736, -9426, -9117, -8808, -8499, -8190, -7880, -7573, -7264, -6954, -6644, -6337, -6027, -5718, -5409, -5100, -4790, -4481, -4172, -3864, -3554, -3245, -2937, -2626, -2318, -2010, -1700, -1390, -1083, -773, -465, -151};