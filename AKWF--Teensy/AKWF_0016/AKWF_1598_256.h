/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1598 256 samples */
 
const int16_t AKWF_1598_256_DATA [256] = 
{24768, 17812, 19112, 18870, 18867, 18866, 18864, 18862, 18859, 18857, 18854, 18851, 18848, 18844, 18840, 18838, 18835, 18830, 18826, 18822, 18819, 18814, 18812, 18807, 18803, 18798, 18793, 18789, 18785, 18781, 18777, 18772, 18768, 18762, 18759, 18753, 18750, 18745, 18740, 18736, 18731, 18726, 18723, 18719, 18714, 18709, 18703, 18700, 18695, 18690, 18686, 18682, 18676, 18671, 18667, 18662, 18659, 18653, 18648, 18644, 18639, 18516, 19088, 16970, -8447, -10564, -9992, -10112, -10116, -10116, -10117, -10118, -10117, -10117, -10117, -10118, -10117, -10115, -10116, -10114, -10112, -10111, -10108, -10105, -10104, -10445, -8612, -20080, -30239, -28435, -28768, -28763, -28758, -28754, -28749, -28744, -28736, -28730, -28725, -28720, -28712, -28706, -28699, -28692, -28686, -28679, -28670, -28662, -28655, -28648, -28640, -28632, -28306, -30084, -22019, 1219, -328, -58, -46, -40, -35, -29, -26, -21, -15, -11, -7, -2, 1, 6, 10, 14, 20, 25, 28, 34, 39, 45, 57, 327, -1220, 22018, 30084, 28306, 28632, 28640, 28648, 28655, 28662, 28670, 28679, 28685, 28692, 28699, 28706, 28712, 28720, 28725, 28730, 28736, 28743, 28749, 28754, 28758, 28762, 28768, 28435, 30239, 20080, 8611, 10444, 10103, 10105, 10107, 10110, 10112, 10113, 10115, 10115, 10116, 10117, 10117, 10117, 10117, 10117, 10117, 10115, 10115, 10112, 9992, 10563, 8446, -16971, -19088, -18517, -18639, -18645, -18649, -18654, -18659, -18663, -18667, -18672, -18676, -18682, -18686, -18691, -18696, -18700, -18704, -18710, -18715, -18719, -18723, -18727, -18732, -18737, -18740, -18746, -18751, -18753, -18759, -18763, -18768, -18773, -18777, -18782, -18785, -18790, -18794, -18799, -18803, -18808, -18812, -18814, -18820, -18822, -18826, -18831, -18835, -18838, -18840, -18845, -18849, -18852, -18855, -18857, -18859, -18862, -18865, -18866, -18868, -18870, -19112, -17813, -24768};