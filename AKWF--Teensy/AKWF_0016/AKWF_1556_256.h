/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1556 256 samples */
 
const int16_t AKWF_1556_256_DATA [256] = 
{466, 1318, 2064, 2724, 3318, 3841, 4312, 4724, 5098, 5429, 5724, 5983, 6219, 6421, 6606, 6770, 6918, 7046, 7160, 7262, 7354, 7435, 7504, 7569, 7623, 7673, 7717, 7755, 7788, 7819, 7844, 7867, 7888, 7904, 7919, 7933, 7944, 7954, 7962, 7968, 7975, 7979, 7982, 7985, 7988, 7988, 7990, 7990, 7990, 7989, 7988, 7988, 7987, 7984, 7982, 7980, 7978, 7976, 7973, 7968, 7966, 7962, 7960, 7957, 7954, 7951, 7947, 7943, 7941, 7936, 7932, 7929, 7926, 7922, 7918, 7914, 7910, 7906, 7902, 7899, 7895, 7891, 7886, 7882, 7879, 7876, 7871, 7866, 7862, 7860, 7857, 7853, 7848, 7844, 7841, 7835, 7831, 7827, 7824, 7820, 7816, 7813, 7808, 7805, 7801, 7797, 7794, 7789, 7783, 7779, 7777, 7772, 7768, 7765, 7761, 7758, 7754, 7749, 7745, 7741, 7738, 7734, 7729, 7725, 7722, 7718, 7714, 7709, 7706, 7702, 7699, 7694, 7690, 7687, 7683, 7679, 7673, 7671, 7688, 7065, 10119, -2394, -33703, -32487, -32716, -32762, -32763, -32760, -32755, -32749, -32743, -32736, -32729, -32722, -32713, -32704, -32693, -32683, -32673, -32663, -32654, -32641, -32630, -32618, -32607, -32595, -32581, -32569, -32556, -32544, -32531, -32518, -32503, -32489, -32478, -32464, -32449, -32435, -32422, -32405, -32373, -31898, -34290, -5308, 10970, 7351, 8100, 8082, 8089, 8095, 8101, 8105, 8109, 8113, 8117, 8119, 8121, 8122, 8123, 8124, 8125, 8124, 8123, 8123, 8122, 8121, 8120, 8117, 8116, 8114, 8112, 8109, 8107, 8103, 8102, 8099, 8096, 8094, 8092, 8088, 8086, 8081, 8079, 8075, 8071, 8069, 8065, 8060, 8057, 8054, 8050, 8048, 8044, 8040, 8036, 8033, 8030, 8025, 8034, 7585, 9837, -4221, -29690, -25231, -21460, -18352, -15451, -12885, -10595, -8568, -6741, -5146, -3692, -2417, -1261, -388};