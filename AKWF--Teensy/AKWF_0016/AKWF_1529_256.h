/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1529 256 samples */
 
const int16_t AKWF_1529_256_DATA [256] = 
{101, 359, 609, 864, 1117, 1369, 1621, 1874, 2125, 2379, 2629, 2880, 3133, 3384, 3635, 3887, 4139, 4388, 4639, 4890, 5143, 5393, 5641, 5891, 6143, 6391, 6641, 6891, 7141, 7390, 7639, 7887, 8138, 8385, 8633, 8882, 9132, 9378, 9627, 9875, 10122, 10370, 10616, 10866, 11112, 11358, 11605, 11853, 12098, 12345, 12590, 12837, 13083, 13331, 13575, 13821, 14065, 14311, 14557, 14801, 15044, 15291, 15535, 15780, 16024, 16268, 16512, 16755, 17000, 17244, 17489, 17729, 17973, 18217, 18459, 18702, 18945, 19187, 19430, 19672, 19914, 20157, 20396, 20638, 20881, 21123, 21363, 21604, 21845, 22085, 22326, 22566, 22808, 23048, 23287, 23527, 23768, 24006, 24246, 24485, 24726, 24965, 25203, 25442, 25681, 25920, 26158, 26396, 26635, 26872, 27109, 27349, 27586, 27823, 28059, 28298, 28535, 28771, 29008, 29245, 29481, 29717, 29953, 30192, 30426, 30661, 30895, 30318, 34975, 4500, -36054, -31682, -32153, -31926, -31678, -31428, -31174, -30920, -30665, -30408, -30148, -29891, -29631, -29370, -29107, -28844, -28582, -28319, -28054, -27790, -27526, -27259, -26994, -26731, -26464, -26199, -25934, -25667, -25403, -25136, -24870, -24604, -24339, -24073, -23806, -23541, -23274, -23009, -22745, -22479, -22213, -21947, -21682, -21419, -21154, -20886, -20623, -20358, -20091, -19828, -19565, -19301, -19036, -18772, -18507, -18246, -17981, -17718, -17455, -17191, -16929, -16667, -16403, -16142, -15877, -15615, -15355, -15092, -14828, -14569, -14306, -14045, -13784, -13523, -13262, -13001, -12739, -12481, -12220, -11959, -11699, -11439, -11179, -10919, -10661, -10401, -10141, -9884, -9624, -9365, -9106, -8847, -8590, -8333, -8073, -7817, -7558, -7300, -7043, -6785, -6529, -6271, -6015, -5758, -5502, -5245, -4987, -4733, -4475, -4221, -3966, -3710, -3453, -3199, -2944, -2687, -2433, -2179, -1925, -1670, -1415, -1163, -907, -654, -400, -143};