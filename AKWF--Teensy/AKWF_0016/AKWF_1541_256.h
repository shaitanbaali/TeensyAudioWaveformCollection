/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1541 256 samples */
 
const int16_t AKWF_1541_256_DATA [256] = 
{44, 189, 331, 476, 617, 760, 904, 1045, 1191, 1334, 1477, 1621, 1759, 1903, 2046, 2188, 2333, 2474, 2616, 2758, 2899, 3043, 3184, 3325, 3469, 3611, 3753, 3894, 4034, 4178, 4318, 4460, 4603, 4743, 4885, 5025, 5165, 5309, 5447, 5591, 5730, 5874, 6014, 6152, 6294, 6435, 6575, 6717, 6856, 6999, 7138, 7276, 7418, 7559, 7699, 7838, 7978, 8121, 8259, 8397, 8538, 8677, 8820, 8958, 9098, 9239, 9374, 9516, 9655, 9794, 9936, 10071, 10212, 10353, 10488, 10630, 10769, 10905, 11044, 11184, 11324, 11462, 11598, 11738, 11876, 12016, 12153, 12292, 12430, 12566, 12706, 12846, 12982, 13121, 13257, 13396, 13535, 13670, 13808, 13946, 14083, 14223, 14359, 14498, 14632, 14767, 14907, 15043, 15181, 15318, 15455, 15592, 15730, 15855, 15943, 16083, 16220, 16354, 16494, 16630, 16766, 16901, 17037, 17175, 17279, 17855, 15212, 26925, 11547, -21395, -17505, -18199, -18031, -17895, -17755, -17612, -17470, -17330, -17187, -17041, -16898, -16753, -16608, -16461, -16316, -16173, -16025, -15878, -15732, -15585, -15439, -15290, -15146, -14999, -14849, -14704, -14554, -14407, -14261, -14112, -13965, -13818, -13670, -13524, -13372, -13226, -13078, -12930, -12784, -12635, -12486, -12341, -12190, -12044, -11895, -11748, -11603, -11452, -11306, -11158, -11011, -10863, -10714, -10570, -10422, -10273, -10127, -9979, -9832, -9684, -9536, -9392, -9244, -9096, -8950, -8800, -8657, -8509, -8362, -8216, -8068, -7924, -7778, -7629, -7483, -7335, -7191, -7045, -6897, -6753, -6605, -6460, -6314, -6166, -6023, -5878, -5731, -5587, -5439, -5294, -5147, -5003, -4859, -4713, -4568, -4422, -4276, -4132, -3985, -3841, -3698, -3551, -3409, -3262, -3119, -2974, -2828, -2685, -2541, -2394, -2253, -2107, -1964, -1818, -1673, -1532, -1388, -1244, -1100, -954, -812, -667, -524, -383, -237, -93};