/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1565 256 samples */
 
const int16_t AKWF_1565_256_DATA [256] = 
{1369, 5106, 6932, 6237, 3864, 1324, -11, 206, 1366, 2425, 2601, 1807, 560, -400, -647, -216, 482, 959, 969, 605, 190, 16, 214, 666, 1139, 1449, 1530, 1484, 1479, 1620, 1918, 2287, 2629, 2857, 2987, 3084, 3215, 3424, 3688, 3961, 4200, 4375, 4512, 4645, 4801, 4986, 5189, 5380, 5543, 5674, 5793, 5921, 6053, 6197, 6339, 6472, 6593, 6702, 6796, 6892, 6998, 7098, 7197, 7287, 7369, 7437, 7506, 7574, 7640, 7708, 7771, 7821, 7870, 7919, 7961, 7996, 8031, 8075, 8106, 8127, 8149, 8169, 8184, 8195, 8208, 8216, 8215, 8213, 8215, 8207, 8194, 8192, 8183, 8170, 8150, 8131, 8109, 8086, 8061, 8032, 7999, 7967, 7933, 7893, 7852, 7809, 7764, 7721, 7672, 7621, 7571, 7517, 7465, 7405, 7348, 7286, 7227, 7163, 7100, 7032, 6969, 6896, 6828, 6754, 6680, 6604, 6527, 6453, 6375, 6291, 6209, 6128, 6049, 5964, 5878, 5790, 5702, 5619, 5526, 5435, 5346, 5252, 5160, 5065, 4969, 4873, 4778, 4681, 4583, 4483, 4385, 4287, 4184, 4082, 3983, 3876, 3776, 3676, 3567, 3468, 3360, 3252, 3149, 3040, 2933, 2830, 2720, 2608, 2499, 2391, 2280, 2167, 2057, 1943, 1834, 1724, 1611, 1496, 1384, 1272, 1158, 1044, 929, 815, 702, 590, 476, 358, 245, 126, 12, -97, -216, -337, -449, -568, -683, -797, -917, -1029, -1145, -1262, -1376, -1489, -1604, -1723, -1842, -1958, -2074, -2188, -2302, -2423, -2531, -2649, -2767, -2884, -2997, -3113, -3224, -3340, -3457, -3570, -3686, -3807, -4139, -3025, -20175, -30928, -30163, -30949, -31409, -31791, -32103, -32350, -32529, -32657, -32738, -32765, -32748, -32689, -32597, -32471, -32324, -32133, -31910, -31672, -31412, -31136, -30838, -30537, -29924, -31046, -22984, -6579, -5664, -2326};