/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1585 256 samples */
 
const int16_t AKWF_1585_256_DATA [256] = 
{11266, 21693, 21999, 25807, 29859, 32511, 32447, 29946, 26467, 23673, 22581, 22955, 23764, 23939, 22991, 21214, 19361, 18129, 17747, 17915, 18091, 17849, 17099, 16111, 15249, 14757, 14646, 14708, 14681, 14419, 13951, 13434, 13040, 12832, 12775, 12364, 14226, -446, -17286, -16705, -17669, -18223, -18623, -18956, -19271, -19562, -19810, -19995, -20078, -20076, -20016, -19933, -19844, -19743, -19609, -19412, -19187, -18923, -18636, -18341, -18045, -17735, -17416, -17072, -16710, -16334, -15955, -15570, -15189, -14805, -14412, -14010, -13606, -13209, -12799, -12399, -12002, -11610, -11213, -10822, -10432, -10041, -9652, -9275, -8898, -8529, -8170, -7806, -7449, -7098, -6752, -6413, -6083, -5756, -5443, -5127, -4812, -4507, -4213, -3921, -3635, -3357, -3085, -2819, -2559, -2306, -2062, -1819, -1580, -1356, -1134, -919, -708, -506, -306, -120, 64, 233, 410, 583, 745, 901, 1050, 1195, 1345, 1489, 1613, 1743, 1865, 1981, 2096, 2205, 2306, 2399, 2496, 2583, 2667, 2749, 2826, 2895, 2963, 3031, 3089, 3140, 3194, 3249, 3293, 3330, 3368, 3400, 3431, 3457, 3481, 3501, 3510, 3523, 3538, 3538, 3542, 3549, 3549, 3546, 3535, 3527, 3515, 3503, 3484, 3463, 3440, 3418, 3392, 3361, 3326, 3289, 3252, 3216, 3174, 3129, 3084, 3037, 2990, 2933, 2884, 2828, 2772, 2716, 2658, 2592, 2535, 2465, 2401, 2330, 2259, 2186, 2113, 2043, 1967, 1885, 1807, 1729, 1652, 1569, 1486, 1398, 1314, 1233, 1141, 1053, 965, 873, 780, 686, 592, 497, 404, 307, 209, 110, 15, -83, -186, -290, -387, -493, -593, -694, -802, -904, -1012, -1120, -1224, -1335, -1440, -1545, -1655, -1769, -1878, -1986, -2100, -2214, -2325, -2440, -2551, -2662, -2777, -2892, -3005, -3118, -3236, -3349, -3465, -3585, -3695, -3837, -3818, -4545};