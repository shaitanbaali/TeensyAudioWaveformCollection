/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1522 256 samples */
 
const int16_t AKWF_1522_256_DATA [256] = 
{1186, 3145, 4783, 6252, 7594, 8842, 10025, 11155, 12262, 13358, 14477, 15677, 17113, 18371, 25244, 18924, 17660, 18271, 18446, 18622, 18762, 18866, 18850, 19336, 15474, 11893, 11061, 10158, 9477, 8901, 8405, 7968, 7577, 7227, 6910, 6621, 6360, 6121, 5905, 5708, 5530, 5368, 5224, 5096, 4982, 4884, 4801, 4733, 4678, 4636, 4607, 4593, 4583, 4573, 4564, 4554, 4543, 4532, 4522, 4512, 4500, 4488, 4477, 4464, 4451, 4438, 4424, 4409, 4396, 4381, 4365, 4350, 4334, 4318, 4302, 4285, 4268, 4250, 4231, 4213, 4193, 4174, 4154, 4134, 4112, 4091, 4069, 4046, 4023, 3999, 3975, 3949, 3924, 3898, 3871, 3851, 3854, 3591, 10182, 13958, 15133, 16288, 17182, 17927, 18568, 19129, 19622, 20062, 20454, 20802, 21113, 21390, 21635, 21851, 22038, 22200, 22335, 22446, 22534, 22597, 22638, 22656, 22651, 22390, 23548, 15718, 5639, 3481, 1134, -644, -2149, -3467, -4642, -5708, -6688, -7597, -8451, -9260, -10041, -10815, -11633, -12335, -14166, -19009, -19365, -19585, -19809, -19983, -20122, -20225, -20207, -20690, -16825, -13240, -12404, -11498, -10811, -10232, -9730, -9286, -8890, -8533, -8209, -7914, -7645, -7399, -7174, -6968, -6780, -6610, -6456, -6318, -6193, -6084, -5990, -5908, -5840, -5786, -5744, -5715, -5693, -5669, -5644, -5619, -5593, -5566, -5537, -5510, -5481, -5451, -5420, -5387, -5354, -5321, -5287, -5251, -5215, -5178, -5141, -5102, -5062, -5021, -4979, -4937, -4893, -4848, -4802, -4755, -4707, -4658, -4607, -4556, -4503, -4449, -4394, -4336, -4278, -4219, -4159, -4093, -4049, -4020, -3954, -3895, -3854, -3544, -10067, -13786, -14911, -16015, -16857, -17552, -18141, -18647, -19085, -19468, -19800, -20090, -20340, -20554, -20734, -20883, -21001, -21091, -21152, -21182, -21185, -21164, -21124, -21054, -20957, -20600, -21657, -13725, -3534, -1224};