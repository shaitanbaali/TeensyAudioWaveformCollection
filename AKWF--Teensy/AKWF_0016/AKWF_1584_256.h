/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1584 256 samples */
 
const int16_t AKWF_1584_256_DATA [256] = 
{16910, 20616, 22663, 26870, 30891, 32337, 33403, 15116, -6002, -7509, -8795, -8524, -8133, -8621, -10201, -12308, -14094, -15023, -15058, -14665, -14425, -14675, -15340, -16080, -16509, -16456, -16060, -15580, -15252, -15165, -15218, -15218, -15032, -14640, -14130, -13638, -13255, -12972, -12729, -12435, -12040, -11563, -11070, -10618, -10210, -9857, -9502, -9122, -8696, -8252, -7811, -7397, -7011, -6646, -6279, -5898, -5514, -5116, -4732, -4371, -4024, -3688, -3353, -3013, -2681, -2345, -2017, -1704, -1408, -1113, -821, -532, -254, 49, 357, 610, 859, 1105, 1346, 1575, 1807, 2028, 2240, 2446, 2647, 2834, 3020, 3191, 3375, 3546, 3711, 3867, 4014, 4163, 4313, 4453, 4577, 4708, 4827, 4945, 5057, 5165, 5261, 5353, 5447, 5531, 5612, 5692, 5765, 5831, 5898, 5958, 6014, 6059, 6110, 6160, 6196, 6231, 6265, 6291, 6315, 6334, 6353, 6365, 6366, 6379, 6383, 6375, 6377, 6375, 6369, 6354, 6339, 6323, 6303, 6283, 6256, 6228, 6197, 6168, 6129, 6090, 6046, 6001, 5956, 5910, 5859, 5806, 5752, 5698, 5634, 5574, 5511, 5450, 5382, 5318, 5245, 5176, 5102, 5025, 4951, 4866, 4787, 4703, 4623, 4543, 4452, 4361, 4274, 4187, 4098, 4002, 3909, 3808, 3719, 3623, 3519, 3423, 3320, 3218, 3116, 3011, 2904, 2800, 2695, 2586, 2476, 2367, 2260, 2146, 2034, 1923, 1808, 1693, 1586, 1468, 1353, 1235, 1115, 1001, 882, 761, 645, 527, 401, 279, 161, 36, -86, -211, -335, -458, -579, -705, -833, -960, -1082, -1207, -1339, -1464, -1592, -1719, -1844, -1971, -2104, -2232, -2362, -2492, -2615, -2746, -2882, -3008, -3140, -3269, -3397, -3530, -3656, -3784, -3916, -4045, -4174, -4300, -4432, -4563, -4695, -4824, -4952, -5082, -5214, -5335, -5471, -5598, -5733, -5762, -6394, -4424};