/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1514 256 samples */
 
const int16_t AKWF_1514_256_DATA [256] = 
{1002, 3094, 5132, 7157, 9156, 11121, 13050, 14923, 16747, 18513, 20205, 21825, 23367, 24819, 26184, 27452, 28617, 29682, 30631, 31409, 32005, 32424, 32675, 32767, 32710, 32514, 32186, 31738, 31181, 30524, 29779, 28957, 28067, 27122, 26131, 25104, 24055, 22988, 21915, 20848, 19788, 18748, 17736, 16755, 15812, 14914, 14062, 13261, 12515, 11822, 11187, 10611, 10088, 9623, 9211, 8850, 8536, 8267, 8036, 7841, 7674, 7530, 7404, 7289, 7178, 7065, 6942, 6804, 6643, 6454, 6228, 5963, 5650, 5285, 4866, 4384, 3838, 3228, 2546, 1793, 972, 78, -885, -1914, -3012, -4169, -5383, -6650, -7960, -9308, -10687, -12085, -13492, -14901, -16297, -17665, -18999, -20276, -21484, -22610, -23628, -24524, -25277, -25863, -26259, -26439, -26373, -26030, -25376, -24341, -23244, -22304, -21289, -20210, -19072, -17883, -16639, -15350, -14020, -12647, -11242, -9806, -8342, -6857, -5353, -3832, -2304, -769, 768, 2303, 3831, 5352, 6856, 8341, 9806, 11241, 12647, 14019, 15349, 16639, 17883, 19072, 20209, 21288, 22304, 23244, 24341, 25376, 26030, 26373, 26439, 26259, 25863, 25277, 24523, 23628, 22609, 21484, 20275, 18999, 17665, 16296, 14901, 13492, 12085, 10686, 9307, 7959, 6649, 5382, 4168, 3011, 1913, 884, -79, -973, -1794, -2547, -3229, -3839, -4384, -4867, -5286, -5651, -5964, -6229, -6455, -6644, -6804, -6942, -7065, -7178, -7289, -7405, -7531, -7675, -7842, -8037, -8268, -8537, -8851, -9212, -9624, -10089, -10611, -11188, -11823, -12515, -13261, -14062, -14915, -15812, -16756, -17737, -18748, -19788, -20848, -21915, -22988, -24055, -25104, -26131, -27122, -28067, -28957, -29779, -30524, -31181, -31738, -32186, -32514, -32710, -32767, -32675, -32424, -32005, -31410, -30631, -29682, -28617, -27452, -26184, -24819, -23367, -21825, -20205, -18513, -16748, -14924, -13051, -11122, -9156, -7158, -5133, -3095, -1003};