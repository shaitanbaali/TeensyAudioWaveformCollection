/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1531 256 samples */
 
const int16_t AKWF_1531_256_DATA [256] = 
{150, 376, 597, 820, 1041, 1261, 1484, 1707, 1928, 2149, 2370, 2592, 2811, 3032, 3252, 3475, 3694, 3915, 4134, 4354, 4573, 4795, 5014, 5233, 5453, 5672, 5891, 6107, 6327, 6547, 6765, 6982, 7202, 7420, 7637, 7855, 8073, 8291, 8510, 8728, 8945, 9162, 9379, 9597, 9814, 10030, 10245, 10462, 10678, 10895, 11113, 11328, 11542, 11760, 11976, 12191, 12408, 12621, 12837, 13052, 13266, 13482, 13697, 13911, 14126, 14340, 14555, 14768, 14981, 15196, 15411, 15623, 15838, 16052, 16263, 16476, 16689, 16903, 17117, 17328, 17539, 17752, 17966, 18176, 18387, 18601, 18813, 19023, 19236, 19446, 19658, 19869, 20082, 20292, 20503, 20712, 20924, 21135, 21344, 21557, 21765, 21975, 22185, 22395, 22605, 22815, 23022, 23232, 23441, 23649, 23859, 24066, 24276, 24484, 24693, 24901, 25110, 25318, 25524, 25733, 25977, 25211, 30332, -4401, -24798, -20502, -21019, -20807, -20587, -20369, -20149, -19926, -19704, -19480, -19256, -19033, -18806, -18579, -18355, -18126, -17898, -17669, -17440, -17213, -16984, -16754, -16524, -16296, -16066, -15839, -15609, -15379, -15149, -14920, -14691, -14463, -14232, -14001, -13759, -13754, -12357, -6006, -21790, -20896, -20799, -20571, -20342, -20112, -19881, -19648, -19419, -19189, -18956, -18725, -18494, -18261, -18030, -17801, -17568, -17337, -17105, -16873, -16645, -16412, -16181, -15950, -15719, -15489, -15257, -15027, -14796, -14566, -14335, -14105, -13876, -13645, -13415, -13187, -12956, -12725, -12496, -12266, -12037, -11809, -11582, -11353, -11123, -10893, -10666, -10437, -10209, -9980, -9752, -9524, -9297, -9069, -8841, -8615, -8385, -8160, -7934, -7707, -7479, -7252, -7025, -6800, -6574, -6348, -6122, -5896, -5669, -5445, -5219, -4993, -4768, -4543, -4318, -4093, -3868, -3643, -3420, -3195, -2971, -2747, -2522, -2298, -2077, -1853, -1629, -1405, -1182, -959, -737, -513, -292, -65};