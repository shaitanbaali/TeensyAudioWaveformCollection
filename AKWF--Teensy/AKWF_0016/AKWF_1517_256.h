/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1517 256 samples */
 
const int16_t AKWF_1517_256_DATA [256] = 
{25312, 25312, 25312, 25312, 25312, 25312, 25312, 25312, 25312, 25312, 25312, 25312, 25312, 25312, 25312, 25312, 25312, 25312, 25312, 25312, 25312, 25312, 25312, 25312, 25312, 25312, 25012, 26632, 18070, 6315, 7997, 7685, 8126, 5755, 18674, 34750, 32313, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32762, 32794, 32664, 31847, 31818, 31814, 31802, 31791, 31781, 31769, 31759, 31748, 31737, 31727, 31716, 31555, 32384, 28790, 13605, 13940, 13898, 13865, 13848, 13832, 13815, 13800, 13755, 13892, 13274, 8731, 8550, 8608, 8594, 8594, 8594, 8594, 8594, 8578, 8663, 8226, 7562, 7651, 7635, 7635, 7635, 7635, 7635, 7635, 7633, 7634, 7648, 6691, 6481, 6531, 6522, 6522, 6522, 6522, 6522, 6522, 6522, 6522, 6434, 6913, 3062, 765, 1224, 1140, 1140, 1140, 1140, 1140, 1140, 1131, 1179, 978, -7, -1, 1, 0, 0, 0, 0, -2, 0, 6, -979, -1180, -1132, -1140, -1140, -1140, -1140, -1140, -1140, -1225, -766, -3063, -6913, -6434, -6522, -6522, -6522, -6522, -6522, -6522, -6522, -6522, -6531, -6482, -6692, -7649, -7634, -7634, -7635, -7635, -7635, -7635, -7635, -7635, -7652, -7563, -8226, -8664, -8579, -8594, -8594, -8594, -8594, -8594, -8609, -8551, -8732, -13275, -13893, -13755, -13800, -13816, -13833, -13849, -13865, -13899, -13941, -13606, -28790, -32384, -31555, -31716, -31727, -31737, -31748, -31759, -31769, -31781, -31791, -31802, -31814, -31818, -31847, -32664, -32794, -32762, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32313, -34750, -18674, -5756, -8127, -7685, -7998, -6316, -18070, -26632, -25012, -25312, -25312, -25312, -25312, -25312, -25312, -25312, -25312, -25312, -25312, -25312, -25312, -25312, -25312, -25312, -25312, -25312, -25312, -25312, -25312, -25312, -25312, -25312, -25312, -25312, -25312};