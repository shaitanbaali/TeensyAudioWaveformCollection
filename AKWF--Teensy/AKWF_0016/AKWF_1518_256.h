/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1518 256 samples */
 
const int16_t AKWF_1518_256_DATA [256] = 
{6264, 22475, 23604, 25007, 26085, 26775, 27601, 28362, 29029, 29626, 30157, 30632, 31052, 31424, 31750, 32031, 32267, 32460, 32609, 32711, 32763, 32759, 32693, 32549, 32301, 31845, 31536, 28497, 24087, 24738, 24885, 25129, 25413, 25654, 26590, 27404, 27420, 27551, 27653, 27745, 27828, 27902, 27966, 28022, 28070, 28107, 28136, 28157, 28172, 28153, 28316, 28345, 28910, 24087, 19991, 19388, 18560, 17962, 17460, 17027, 16644, 16298, 15983, 15694, 15425, 15175, 14941, 14719, 14511, 14313, 14125, 13945, 13774, 13610, 13453, 13304, 13159, 13019, 12885, 12757, 12632, 12511, 12395, 12283, 12174, 12069, 11967, 11868, 11773, 11680, 11590, 11501, 11416, 11333, 11252, 11174, 11096, 11019, 10946, 10873, 10801, 10730, 10659, 10587, 10477, 10615, 9534, 6948, 6489, 6028, 5662, 5336, 5031, 4734, 4435, 4121, 3742, 3451, 1958, 460, 575, 460, 385, 313, 241, 171, 102, 33, -34, -103, -172, -242, -314, -386, -461, -576, -461, -1959, -3452, -3743, -4122, -4436, -4735, -5032, -5336, -5663, -6029, -6489, -6949, -9534, -10616, -10478, -10588, -10659, -10731, -10801, -10873, -10946, -11020, -11097, -11174, -11253, -11334, -11417, -11502, -11591, -11681, -11774, -11869, -11968, -12070, -12175, -12283, -12396, -12512, -12632, -12757, -12885, -13019, -13159, -13304, -13454, -13611, -13775, -13946, -14126, -14314, -14511, -14719, -14941, -15176, -15426, -15695, -15984, -16299, -16644, -17028, -17460, -17963, -18560, -19388, -19991, -24088, -28910, -28345, -28317, -28153, -28172, -28157, -28136, -28107, -28070, -28023, -27966, -27902, -27828, -27746, -27653, -27551, -27421, -27404, -26590, -25654, -25413, -25129, -24885, -24738, -24087, -28497, -31537, -31845, -32301, -32549, -32693, -32759, -32763, -32711, -32609, -32460, -32267, -32031, -31750, -31424, -31053, -30632, -30157, -29626, -29029, -28362, -27601, -26775, -26086, -25007, -23604, -22475, -6265};