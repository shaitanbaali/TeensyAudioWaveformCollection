/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1537 256 samples */
 
const int16_t AKWF_1537_256_DATA [256] = 
{100, 400, 691, 983, 1275, 1566, 1858, 2149, 2441, 2734, 3021, 3312, 3604, 3894, 4184, 4474, 4765, 5054, 5342, 5633, 5923, 6210, 6498, 6787, 7077, 7364, 7653, 7939, 8229, 8516, 8804, 9091, 9377, 9663, 9950, 10237, 10528, 10781, 11024, 11319, 11606, 11895, 12180, 12465, 12754, 13040, 13326, 13613, 13899, 14183, 14468, 14755, 15042, 15327, 15610, 15895, 16181, 16463, 16749, 17033, 17316, 17599, 17883, 18167, 18451, 18732, 19017, 19300, 19582, 19863, 20147, 20428, 20707, 20991, 21273, 21552, 21835, 22114, 22398, 22678, 22957, 23237, 23517, 23796, 24077, 24357, 24712, 23818, 29931, 5445, -23205, -18706, -19184, -18901, -18612, -18322, -18028, -17737, -17444, -17149, -16853, -16556, -16261, -15964, -15668, -15368, -15073, -14773, -14474, -14177, -13878, -13578, -13279, -12981, -12682, -12383, -12082, -11783, -11486, -11186, -10886, -10589, -10289, -9990, -9691, -9393, -9095, -8797, -8497, -8201, -7901, -7606, -7306, -7009, -6713, -6416, -6118, -5821, -5523, -5226, -4933, -4638, -4339, -4041, -3747, -3451, -3158, -2862, -2567, -2272, -1976, -1682, -1391, -1095, -801, -506, -214, 77, 372, 665, 957, 1251, 1542, 1835, 2125, 2419, 2712, 3001, 3292, 3584, 3877, 4165, 4457, 4748, 5038, 5327, 5618, 5908, 6197, 6486, 6777, 7065, 7355, 7643, 7930, 8219, 8509, 8943, 7686, 15039, -2518, -22311, -18189, -18566, -18275, -17982, -17688, -17391, -17096, -16799, -16504, -16204, -15909, -15611, -15312, -15014, -14717, -14419, -14118, -13819, -13520, -13222, -12924, -12625, -12326, -12026, -11728, -11433, -11131, -10831, -10534, -10238, -9938, -9642, -9342, -9044, -8747, -8449, -8154, -7855, -7556, -7259, -6965, -6668, -6370, -6072, -5777, -5481, -5185, -4890, -4595, -4299, -4002, -3711, -3416, -3121, -2826, -2531, -2237, -1945, -1650, -1357, -1064, -768, -480, -180};