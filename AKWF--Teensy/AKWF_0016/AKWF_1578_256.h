/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1578 256 samples */
 
const int16_t AKWF_1578_256_DATA [256] = 
{4301, 4790, 4510, 4416, 4294, 4318, 3379, 10830, 22800, 22543, 22096, 21809, 21472, 21137, 20806, 20474, 20146, 19822, 19501, 19170, 19134, 17414, 25862, 33394, 31767, 31709, 31400, 31102, 30805, 30509, 30216, 29926, 29636, 29351, 29069, 28787, 28510, 28231, 27956, 27689, 27418, 27150, 26884, 26621, 26363, 26106, 25850, 25598, 25340, 24982, 25352, 18714, 7826, 7482, 7582, 7483, 7443, 7405, 7361, 7324, 7283, 7246, 7208, 7169, 7132, 7096, 7058, 7024, 6988, 6953, 6920, 6883, 6849, 6817, 6782, 6750, 6717, 6684, 6653, 6621, 6591, 6560, 6530, 6499, 6469, 6441, 6412, 6383, 6354, 6326, 6299, 6272, 6243, 6219, 6192, 6165, 6140, 6114, 6089, 6064, 6039, 6014, 5989, 5965, 5941, 5917, 5895, 5872, 5847, 5826, 5803, 5779, 5757, 5736, 5715, 5694, 5671, 5652, 5632, 5611, 5590, 5571, 5552, 5535, 5513, 5498, 5440, 5449, 5488, -5534, -14250, -13240, -13150, -12960, -12757, -12555, -12357, -12159, -11964, -11771, -11576, -11388, -11199, -11012, -10825, -10639, -10457, -10277, -10096, -9918, -9742, -9565, -9392, -9219, -9050, -8880, -8711, -8546, -8379, -8217, -8054, -7896, -7735, -7577, -7419, -7266, -7111, -6958, -6810, -6658, -6513, -6359, -6220, -6073, -5929, -5957, -4827, -15664, -20677, -19396, -19484, -19345, -19212, -19076, -18944, -18813, -18683, -18554, -18426, -18298, -18172, -18048, -17924, -17799, -17677, -17555, -17437, -17316, -17199, -17082, -16964, -16851, -16737, -16625, -16511, -16400, -16291, -16183, -16074, -15966, -15862, -15755, -15652, -15549, -15449, -15346, -15245, -15146, -15048, -14950, -14852, -14757, -14660, -14567, -14474, -14382, -14290, -14200, -14110, -14022, -13933, -13846, -13759, -13675, -13588, -13504, -13421, -13338, -13256, -13175, -13095, -13016, -12935, -12859, -12782, -12705, -12629, -12555, -12479, -12406, -12332, -12259, -12182, -12016, -12478, -6107};