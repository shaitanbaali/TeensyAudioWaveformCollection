/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1540 256 samples */
 
const int16_t AKWF_1540_256_DATA [256] = 
{39, 165, 289, 412, 534, 655, 778, 904, 1026, 1151, 1274, 1397, 1520, 1640, 1763, 1887, 2010, 2135, 2255, 2378, 2501, 2623, 2742, 2866, 2989, 3112, 3234, 3355, 3479, 3601, 3721, 3846, 3953, 4167, 4355, 4463, 4587, 4710, 4831, 4951, 5075, 5196, 5319, 5439, 5560, 5682, 5805, 5923, 6046, 6168, 6291, 6411, 6530, 6653, 6774, 6893, 7017, 7136, 7257, 7379, 7497, 7618, 7741, 7859, 7982, 8101, 8221, 8345, 8463, 8581, 8704, 8822, 8945, 9064, 9183, 9305, 9423, 9542, 9662, 9782, 9902, 10020, 10140, 10262, 10379, 10499, 10619, 10738, 10858, 10976, 11095, 11217, 11334, 11453, 11572, 11689, 11809, 11927, 12048, 12168, 12282, 12401, 12523, 12638, 12758, 12875, 12995, 13114, 13230, 13348, 13467, 13584, 13703, 13821, 13939, 14058, 14175, 14291, 14410, 14526, 14646, 14762, 14879, 15000, 15079, 15613, 12998, 26574, 4051, -20418, -14756, -15769, -15559, -15443, -15320, -15200, -15075, -14950, -14827, -14702, -14581, -14457, -14330, -14205, -14078, -13952, -13827, -13696, -13571, -13447, -13319, -13194, -13065, -12936, -12811, -12683, -12557, -12432, -12301, -12174, -12047, -11917, -11792, -11664, -11536, -11409, -11282, -11155, -11026, -10898, -10772, -10642, -10516, -10391, -10260, -10133, -10007, -9877, -9752, -9623, -9495, -9370, -9242, -9114, -8988, -8860, -8736, -8605, -8479, -8356, -8226, -8099, -7972, -7843, -7718, -7591, -7464, -7338, -7213, -7086, -6960, -6830, -6706, -6580, -6453, -6327, -6201, -6075, -5949, -5821, -5696, -5570, -5445, -5321, -5194, -5067, -4942, -4815, -4692, -4565, -4438, -4314, -4189, -4062, -3939, -3813, -3690, -3562, -3435, -3313, -3190, -3062, -2939, -2812, -2689, -2564, -2439, -2317, -2191, -2066, -1942, -1817, -1694, -1570, -1444, -1321, -1198, -1072, -950, -825, -700, -576, -452, -330, -207, -78};