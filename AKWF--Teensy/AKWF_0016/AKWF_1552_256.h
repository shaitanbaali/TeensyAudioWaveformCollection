/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1552 256 samples */
 
const int16_t AKWF_1552_256_DATA [256] = 
{592, 1423, 2087, 2631, 3085, 3461, 3771, 4023, 4232, 4405, 4547, 4664, 4760, 4838, 4903, 4955, 4998, 5034, 5062, 5083, 5102, 5118, 5131, 5138, 5145, 5149, 5154, 5155, 5157, 5158, 5157, 5158, 5157, 5155, 5151, 5150, 5148, 5145, 5143, 5140, 5138, 5135, 5131, 5128, 5125, 5122, 5118, 5116, 5111, 5108, 5105, 5101, 5097, 5094, 5091, 5088, 5083, 5080, 5077, 5074, 5070, 5066, 5062, 5059, 5056, 5052, 5050, 5046, 5042, 5040, 5036, 5031, 5028, 5024, 5022, 5018, 5014, 5010, 5007, 5004, 4949, 4858, 5846, -21767, -34546, -32361, -32760, -32757, -32750, -32742, -32735, -32726, -32714, -32702, -32691, -32678, -32666, -32651, -32636, -32621, -32606, -32591, -32576, -32559, -32542, -32479, -32259, -33671, -7321, 7334, 4816, 5298, 5305, 5313, 5320, 5326, 5331, 5335, 5339, 5342, 5344, 5345, 5346, 5347, 5348, 5348, 5348, 5346, 5346, 5344, 5344, 5343, 5339, 5338, 5335, 5332, 5330, 5328, 5326, 5323, 5320, 5317, 5314, 5311, 5308, 5305, 5302, 5298, 5295, 5291, 5289, 5286, 5283, 5280, 5275, 5272, 5269, 5265, 5261, 5258, 5254, 5251, 5248, 5244, 5240, 5237, 5233, 5229, 5228, 5224, 5220, 5216, 5213, 5209, 5208, 4766, 7119, -4107, -27508, -20821, -16379, -12676, -9540, -6962, -4834, -3071, -1644, -333, 767, 1556, 2226, 2772, 3223, 3597, 3905, 4157, 4366, 4538, 4679, 4795, 4891, 4970, 5033, 5087, 5129, 5164, 5192, 5216, 5233, 5248, 5259, 5267, 5275, 5281, 5284, 5285, 5288, 5287, 5288, 5287, 5285, 5284, 5282, 5280, 5277, 5274, 5271, 5268, 5266, 5262, 5259, 5256, 5253, 5249, 5246, 5243, 5240, 5235, 5231, 5229, 5226, 5222, 5211, 4767, 7350, -13333, -29008, -20163, -16277, -12500, -9387, -6840, -4741, -2991, -1553, -354};