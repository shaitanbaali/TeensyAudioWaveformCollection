/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1576 256 samples */
 
const int16_t AKWF_1576_256_DATA [256] = 
{5440, 6428, 5961, 5828, 5638, 5457, 5271, 5089, 4908, 4727, 4552, 4373, 4197, 4022, 3849, 3679, 3721, 2516, 8614, 29730, 32830, 31579, 31243, 30738, 30235, 29739, 29248, 28759, 28276, 27796, 27317, 26846, 26380, 25915, 25455, 24996, 24545, 24098, 23653, 23215, 22778, 22343, 21916, 21493, 21073, 20657, 20242, 19835, 19422, 18842, 19415, 9662, -7704, -8485, -8442, -8385, 10874, 14485, 13492, 13585, 13514, 13438, 13365, 13289, 13215, 13143, 13069, 12998, 12926, 12855, 12786, 12716, 12646, 12580, 12511, 12444, 12380, 12312, 12250, 12183, 12120, 12059, 11994, 11932, 11870, 11809, 11751, 11691, 11632, 11572, 11514, 11457, 11399, 11345, 11289, 11233, 11177, 11124, 11070, 11018, 10964, 10914, 10863, 10810, 10760, 10712, 10662, 10613, 10565, 10517, 10469, 10422, 10378, 10331, 10285, 10242, 10195, 10151, 10108, 10062, 10019, 9979, 9934, 9894, 9852, 9810, 9772, 9730, 9692, 9653, 9614, 9577, 9537, 9501, 9467, 9427, 9396, 9342, 9128, 10163, -1757, -20230, -20260, -19737, -19515, -19204, -18896, -18596, -18291, -17990, -17696, -17399, -17110, -16819, -16529, -16245, -15962, -15683, -15405, -15129, -14856, -14585, -14316, -14052, -13788, -13528, -13268, -13012, -12757, -12504, -12253, -12005, -11759, -11517, -11274, -11035, -10797, -10560, -10327, -10098, -9869, -9640, -9417, -9191, -8972, -8750, -8536, -8321, -8105, -7893, -7685, -7480, -7271, -7070, -6867, -6669, -6469, -6275, -6080, -5886, -5697, -5507, -5321, -5135, -4951, -4769, -4587, -4415, -4392, -3381, -6509, -25668, -26148, -25723, -25612, -25450, -25281, -25123, -24951, -24792, -24632, -24471, -24309, -24151, -23999, -23839, -23687, -23533, -23386, -23233, -23085, -22940, -22793, -22648, -22504, -22363, -22220, -22082, -21942, -21808, -21671, -21535, -21402, -21269, -21138, -21005, -20879, -20750, -20622, -20496, -20372, -20246, -20115, -19842, -20591, -11241};