/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1542 256 samples */
 
const int16_t AKWF_1542_256_DATA [256] = 
{397, 1168, 2101, 2958, 3806, 4740, 5753, 6882, 7996, 9140, 10421, 11812, 13178, 14595, 16136, 17568, 19050, 20500, 21941, 23354, 24697, 26088, 27188, 28326, 29304, 30232, 31035, 31607, 32117, 32477, 32694, 32738, 32691, 32533, 32189, 31743, 31123, 30338, 29498, 28455, 27315, 26186, 24953, 23590, 22155, 20624, 19070, 17540, 15959, 14360, 12649, 11029, 9516, 7831, 6261, 4684, 3251, 1704, 299, -1086, -2425, -3673, -4855, -6075, -7101, -8197, -9172, -10143, -11010, -11813, -12573, -13255, -13829, -14470, -14984, -15412, -15793, -16038, -16343, -16535, -16543, -16505, -16451, -16197, -16002, -15687, -15366, -14932, -14410, -13857, -13263, -12579, -11852, -11081, -10231, -9400, -8483, -7535, -6556, -5587, -4600, -3566, -2555, -1575, -702, 273, 1218, 2088, 2990, 3722, 4518, 5292, 5917, 6482, 7073, 7565, 7984, 8326, 8664, 8950, 9204, 9406, 9461, 9457, 9422, 9309, 9228, 9045, 8899, 8597, 8284, 7965, 7490, 7098, 6603, 6071, 5517, 4995, 4334, 3627, 2849, 2091, 1390, 475, -418, -1379, -2347, -3345, -4345, -5420, -6484, -7551, -8662, -9622, -10737, -11774, -12741, -13848, -14668, -15589, -16414, -17150, -17776, -18282, -18699, -19054, -19291, -19333, -19237, -19050, -18699, -18138, -17502, -16749, -15798, -14656, -13414, -12123, -10678, -9119, -7548, -5888, -4252, -2625, -961, 557, 2001, 3368, 4759, 5981, 7024, 7935, 8740, 9410, 9868, 10227, 10467, 10372, 10133, 9897, 9431, 8728, 7921, 7006, 5966, 4758, 3445, 2119, 626, -891, -2431, -3967, -5581, -7132, -8625, -10116, -11511, -12757, -13970, -15038, -15972, -16855, -17531, -18041, -18471, -18721, -18893, -18883, -18781, -18568, -18246, -17891, -17364, -16789, -16209, -15488, -14708, -13950, -13125, -12304, -11494, -10714, -9920, -9140, -8284, -7497, -6714, -6008, -5296, -4515, -3773, -3099, -2423, -1695, -1008, -270};