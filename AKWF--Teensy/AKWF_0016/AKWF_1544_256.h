/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1544 256 samples */
 
const int16_t AKWF_1544_256_DATA [256] = 
{1372, 3504, 5209, 6621, 7787, 8755, 9551, 10207, 10750, 11195, 11561, 11864, 12114, 12318, 12486, 12624, 12735, 12828, 12903, 12963, 13012, 13051, 13082, 13107, 13126, 13140, 13150, 13157, 13162, 13166, 13167, 13165, 13164, 13161, 13156, 13151, 13148, 13143, 13137, 13130, 13124, 13117, 13109, 13103, 13095, 13088, 13081, 13073, 13065, 13056, 13049, 13041, 13034, 13025, 13017, 13008, 13001, 12994, 12984, 12976, 12969, 12961, 12952, 12944, 12936, 12928, 12920, 12912, 12904, 12895, 12888, 12879, 12871, 12863, 12856, 12848, 12839, 12831, 12823, 12815, 12807, 12799, 12790, 12783, 12749, 12313, 14889, -17219, -35129, -32019, -32592, -32594, -32590, -32586, -32579, -32572, -32562, -32552, -32542, -32531, -32519, -32506, -32493, -32479, -32464, -32450, -32436, -32420, -32403, -32381, -31814, -34852, -5377, 15851, 12349, 13012, 13015, 13023, 13026, 13031, 13032, 13035, 13035, 13035, 13033, 13032, 13029, 13025, 13022, 13019, 13014, 13008, 13004, 13000, 12995, 12989, 12983, 12975, 12969, 12962, 12955, 12950, 12942, 12936, 12927, 12920, 12913, 12906, 12898, 12890, 12883, 12876, 12867, 12860, 12853, 12845, 12837, 12828, 12821, 12814, 12806, 12797, 12789, 12781, 12773, 12767, 12758, 12750, 12743, 12734, 12725, 12719, 12711, 12702, 12694, 12685, 12678, 12671, 12662, 12654, 12648, 12638, 12631, 12622, 12614, 12606, 12598, 12590, 12583, 12575, 12567, 12558, 12551, 12542, 12535, 12527, 12519, 12511, 12503, 12495, 12487, 12480, 12471, 12466, 12165, 13527, 7804, -28803, -33566, -32536, -32766, -32766, -32763, -32758, -32750, -32741, -32731, -32722, -32711, -32700, -32687, -32674, -32660, -32646, -32632, -32617, -32601, -32585, -32569, -32553, -32537, -32520, -32503, -32485, -32468, -32451, -32433, -32415, -32398, -32380, -32361, -32344, -32325, -32307, -32289, -32272, -32252, -32190, -32314, -31591, -25116, -18239, -12816, -8291, -4568, -1375};