/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1564 256 samples */
 
const int16_t AKWF_1564_256_DATA [256] = 
{488, 1209, 1865, 2499, 3106, 3684, 4256, 4827, 5374, 5923, 6447, 6950, 7431, 7899, 8341, 8782, 9193, 9620, 10031, 10411, 10778, 11131, 11473, 11831, 12159, 12454, 12763, 13042, 13314, 13574, 13827, 14064, 14276, 14493, 14693, 14883, 15068, 15237, 15391, 15545, 15691, 15819, 15923, 16039, 16161, 16245, 16320, 16392, 16455, 16513, 16557, 16597, 16628, 16630, 16649, 16660, 16641, 16636, 16628, 16614, 16584, 16544, 16504, 16453, 16401, 16341, 16269, 16189, 16116, 16024, 15929, 15825, 15717, 15605, 15495, 15369, 15241, 15111, 14981, 14833, 14683, 14536, 14383, 14221, 14066, 13892, 13724, 13548, 13357, 13185, 12986, 12794, 12591, 12396, 12209, 11991, 11772, 11558, 11352, 11138, 10911, 10688, 10447, 10231, 10000, 9751, 9522, 9281, 9035, 8788, 8533, 8281, 8031, 7782, 7519, 7259, 6992, 6738, 6468, 6195, 5934, 5660, 5380, 5127, 4841, 4571, 4295, 4003, 3724, 3445, 3150, 2879, 2595, 2296, 1997, 1718, 1424, 1130, 828, 534, 233, -51, -350, -655, -957, -1251, -1553, -1865, -2169, -2473, -2773, -3072, -3376, -3689, -3998, -4306, -4619, -4910, -5224, -5547, -5853, -6163, -6477, -6781, -7096, -7401, -7706, -8020, -8327, -8634, -8933, -9252, -9566, -9881, -10188, -10495, -10798, -11120, -11425, -11724, -12044, -12355, -12660, -12965, -13277, -13563, -13894, -14192, -14494, -14673, -15833, -12941, 5148, -22638, -20718, -12480, -3607, 1555, -22, -7216, -16168, -22775, -24926, -23499, -21227, -20713, -22932, -26918, -30697, -32662, -32420, -30967, -29637, -29403, -30323, -31669, -32503, -32309, -31202, -29766, -28628, -28081, -27956, -27859, -27396, -26439, -25155, -23870, -22850, -22080, -21466, -20789, -19914, -18837, -17692, -16609, -15668, -14848, -14075, -13240, -12325, -11363, -10380, -9470, -8637, -7854, -7091, -6305, -5485, -4673, -3860, -3085, -2367, -1684, -1002, -296};