/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1526 256 samples */
 
const int16_t AKWF_1526_256_DATA [256] = 
{5746, 22855, 30535, 32572, 32684, 32245, 31672, 31082, 30492, 29912, 29344, 28785, 28236, 27702, 27135, 26694, 25463, 18117, 4158, -11823, -23432, -28097, -29156, -29039, -28594, -28074, -27545, -27023, -26509, -26004, -25504, -25005, -24546, -22019, -15489, -6819, 2094, 10429, 17801, 24028, 28435, 30273, 30490, 30136, 29617, 29057, 28538, 27527, 25014, 21249, 16894, 12346, 7813, 3465, -557, -4174, -7287, -9842, -11815, -13185, -13964, -14178, -13870, -13099, -11924, -10431, -8692, -6778, -4777, -2754, -775, 1089, 2798, 4314, 5599, 6636, 7415, 7933, 8201, 8228, 8040, 7664, 7125, 6462, 5702, 4885, 4043, 3199, 2384, 1622, 932, 329, -177, -578, -877, -1071, -1167, -1174, -1102, -966, -775, -551, -304, -51, 198, 427, 623, 781, 894, 955, 957, 903, 794, 632, 419, 162, -134, -460, -807, -1169, -1536, -1904, -2266, -2610, -2932, -3227, -3490, -3715, -3905, -4055, -4165, -4237, -4270, -4267, -4227, -4161, -4065, -3947, -3808, -3656, -3490, -3317, -3139, -2960, -2781, -2609, -2441, -2281, -2130, -1987, -1857, -1738, -1629, -1529, -1440, -1359, -1284, -1216, -1155, -1098, -1044, -994, -945, -897, -849, -801, -753, -706, -657, -608, -556, -506, -456, -406, -356, -306, -257, -210, -163, -118, -76, -38, -1, 31, 64, 92, 117, 141, 162, 182, 199, 213, 227, 240, 249, 259, 268, 279, 285, 291, 299, 306, 314, 321, 327, 334, 342, 346, 354, 361, 365, 370, 378, 382, 385, 390, 393, 397, 400, 402, 405, 406, 409, 406, 405, 406, 403, 402, 403, 401, 399, 397, 394, 391, 388, 384, 382, 383, 364, 378, 113, -3227, -11923, -20772, -24818, -25795, -25705, -25318, -24859, -24393, -23931, -23475, -22986, -22648, -21617, -12267};