/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1570 256 samples */
 
const int16_t AKWF_1570_256_DATA [256] = 
{8780, 18979, 18275, 18229, 18134, 18018, 17908, 17795, 17683, 17573, 17461, 17355, 17245, 17137, 17030, 16924, 16819, 16713, 16608, 16507, 16403, 16301, 16202, 16101, 16002, 15903, 15803, 15706, 15610, 15512, 15420, 15325, 15230, 15139, 15045, 14954, 14863, 14774, 14687, 14596, 14509, 14423, 14335, 14251, 14164, 14083, 14001, 13915, 13838, 13726, 13601, 13919, 3125, -7522, -6706, -6613, -6478, -6319, -6163, -6004, -5813, -5640, -5789, 7849, 18778, 17641, 17664, 17559, 17436, 17314, 17196, 17075, 16956, 16840, 16721, 16606, 16491, 16376, 16265, 16150, 16041, 15931, 15824, 15709, 15612, 15505, 15138, 16400, 3202, -3607, -2312, -2687, -2774, -2876, -2963, -3063, -3158, -3249, -3343, -3433, -3527, -3614, -3705, -3792, -3881, -3965, -4051, -4134, -4219, -4301, -4381, -4465, -4543, -4624, -4700, -4779, -4856, -4931, -5007, -5080, -5156, -5229, -5301, -5371, -5444, -5514, -5584, -5654, -5720, -5789, -5856, -5922, -5988, -6053, -6118, -6182, -6245, -6308, -6370, -6431, -6491, -6551, -6611, -6671, -6729, -6787, -6844, -6901, -6958, -7012, -7067, -7121, -7174, -7228, -7280, -7333, -7384, -7435, -7486, -7535, -7585, -7636, -7683, -7730, -7780, -7827, -7875, -7921, -7967, -8010, -8056, -8100, -8147, -8189, -8231, -8275, -8315, -8359, -8396, -8438, -8478, -8514, -8658, -8314, -10316, -26183, -33708, -26319, -12775, -13761, -13315, -13093, -12866, -12641, -12421, -12201, -11985, -11769, -11554, -11343, -11133, -10925, -10721, -10515, -10312, -10114, -9914, -9720, -9524, -9330, -9139, -8949, -8761, -8575, -8388, -8205, -8025, -7844, -7667, -7488, -7314, -7140, -6968, -6797, -6627, -6460, -6294, -6129, -5968, -5806, -5643, -5487, -5330, -5175, -5023, -4868, -4716, -4568, -4419, -4273, -4126, -3982, -3839, -3696, -3557, -3416, -3277, -3142, -3005, -2870, -2739, -2603, -2475, -2333, -2256, -1835};