/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1509 256 samples */
 
const int16_t AKWF_1509_256_DATA [256] = 
{8191, 8191, 8191, 8192, 8192, 8192, 8192, 8192, 8191, 8191, 8192, 8192, 8192, 8326, 7597, 13457, 16957, 16315, 16082, 22876, 24963, 24492, 24576, 24576, 24576, 24576, 24576, 24576, 24575, 24576, 24576, 24576, 24576, 24576, 24576, 24576, 24576, 24576, 24575, 24576, 24576, 24576, 24659, 24188, 26275, 33068, 32687, 32819, 32606, 25411, 24363, 24625, 24576, 24576, 24576, 24576, 24576, 24576, 24575, 24576, 24576, 24576, 24576, 24575, 24575, 24576, 24575, 24576, 24576, 24576, 24533, 24755, 23891, 16663, 16383, 16003, 18124, 24772, 17237, 16149, 16436, 16384, 16384, 16383, 16383, 16384, 16383, 16383, 16383, 16384, 16383, 16383, 16384, 16383, 16384, 16384, 16384, 16384, 16383, 16344, 16546, 15772, 8533, 8092, 8220, 8191, 8191, 8191, 8191, 8191, 8191, 8191, 8191, 8192, 8191, 8191, 8191, 8191, 8192, 8191, 8042, 8843, 3701, -638, 145, 0, 0, -1, -1, -1, -114, 516, -2499, -8719, -8076, -8192, -8192, -8192, -8192, -8191, -8191, -8192, -8192, -8191, -8192, -8192, -8192, -8192, -8192, -8192, -8198, -8233, -7967, -14871, -16737, -16308, -16384, -16384, -16385, -16384, -16385, -16384, -16385, -16384, -16383, -16385, -16384, -16384, -16384, -16384, -16384, -16383, -16384, -16384, -16404, -16329, -16415, -24322, -19415, -15781, -16560, -16120, -22970, -24946, -24496, -24576, -24577, -24576, -24575, -24576, -24575, -24576, -24576, -24576, -24577, -24576, -24576, -24576, -24577, -24577, -24576, -24576, -24577, -24594, -24535, -24682, -31854, -32998, -32584, -33348, -27394, -24018, -24700, -24577, -24577, -24576, -24575, -24576, -24576, -24576, -24576, -24576, -24577, -24576, -24576, -24576, -24576, -24576, -24576, -24576, -24576, -24576, -24576, -24530, -24772, -23817, -16603, -16227, -16811, -14589, -7857, -8261, -8195, -8192, -8193, -8192, -8192, -8193, -8192, -8193, -8192, -8193, -8184, -8172, -8333, -1333};