/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1535 256 samples */
 
const int16_t AKWF_1535_256_DATA [256] = 
{95, 326, 551, 777, 1002, 1228, 1454, 1679, 1906, 2129, 2352, 2579, 2806, 3029, 3254, 3478, 3703, 3925, 4150, 4374, 4598, 4820, 5045, 5269, 5493, 5714, 5937, 6158, 6381, 6605, 6828, 7048, 7271, 7492, 7716, 7937, 8157, 8377, 8601, 8822, 9042, 9265, 9486, 9705, 9925, 10147, 10369, 10589, 10808, 11030, 11251, 11471, 11691, 11910, 12130, 12349, 12570, 12789, 13008, 13227, 13447, 13666, 13886, 14103, 14320, 14541, 14760, 14977, 15195, 15413, 15631, 15847, 16067, 16285, 16501, 16717, 16935, 17153, 17370, 17587, 17802, 18018, 18234, 18451, 18668, 18884, 19098, 19315, 19531, 19746, 19961, 20176, 20392, 20606, 20821, 21037, 21252, 21464, 21679, 21894, 22109, 22323, 22536, 22749, 23036, 22391, 26978, -4506, -19641, -16473, -16775, -16552, -16334, -16110, -15884, -15660, -15433, -15207, -14980, -14751, -14524, -14293, -14064, -13834, -13605, -13375, -13143, -12911, -12680, -12450, -12219, -11986, -11756, -11524, -11293, -11063, -10832, -10599, -10368, -10137, -9904, -9673, -9441, -9209, -8978, -8748, -8518, -8287, -8054, -7823, -7593, -7363, -7133, -6903, -6673, -6442, -6213, -5982, -5753, -5523, -5292, -5065, -4834, -4606, -4376, -4147, -3918, -3690, -3459, -3231, -3002, -2773, -2546, -2317, -2090, -1860, -1632, -1405, -1176, -747, -1981, 5025, -8645, -18545, -16141, -16256, -16028, -15797, -15568, -15337, -15105, -14872, -14642, -14408, -14176, -13944, -13712, -13478, -13245, -13014, -12782, -12547, -12315, -12081, -11849, -11618, -11384, -11150, -10919, -10686, -10454, -10224, -9990, -9757, -9524, -9294, -9062, -8831, -8598, -8366, -8135, -7905, -7674, -7444, -7212, -6981, -6751, -6522, -6292, -6059, -5829, -5600, -5370, -5141, -4911, -4683, -4451, -4223, -3996, -3766, -3537, -3307, -3080, -2854, -2625, -2394, -2168, -1940, -1712, -1485, -1259, -1032, -804, -576, -353, -122};