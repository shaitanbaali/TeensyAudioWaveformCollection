/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1580 256 samples */
 
const int16_t AKWF_1580_256_DATA [256] = 
{1026, 493, 712, 759, 832, 906, 978, 1049, 1119, 1188, 1257, 1325, 1392, 1458, 1522, 1588, 1651, 1714, 1778, 1839, 1902, 1961, 2020, 2083, 2149, 2327, 1693, 9037, 19579, 19385, 19181, 19080, 18937, 18796, 18658, 18519, 18381, 18244, 18206, 17667, 19909, 30388, 32915, 32120, 31928, 31623, 31326, 31030, 30738, 30447, 30158, 29871, 29587, 29305, 29028, 28749, 28475, 28203, 27932, 27663, 27399, 27135, 26871, 26613, 26356, 26102, 25849, 25597, 25349, 25103, 24858, 24616, 24375, 24137, 23901, 23668, 23436, 23206, 22978, 22752, 22529, 22308, 22087, 21870, 21655, 21440, 21230, 21021, 20811, 20608, 20380, 20156, 20205, 11882, 4115, 4617, 4536, 4501, 4483, 4466, 4445, 4429, 4412, 4395, 4380, 4362, 4347, 4332, 4316, 4300, 4286, 4272, 4257, 4243, 4230, 4217, 4202, 4189, 4175, 4162, 4150, 4137, 4124, 4113, 4100, 4088, 4076, 4065, 4053, 4043, 4031, 4020, 4009, 3999, 3988, 3977, 3969, 3957, 3949, 3938, 3930, 3920, 3909, 3902, 3894, 3883, 3877, 3833, 3861, 3840, -6242, -13860, -12945, -12946, -12322, -13868, -24932, -25197, -24840, -24702, -24522, -24342, -24163, -23983, -23807, -23631, -23456, -23285, -23114, -22942, -22773, -22606, -22439, -22275, -22111, -21949, -21789, -21628, -21471, -21314, -21156, -21003, -20850, -20698, -20548, -20398, -20249, -20103, -19958, -19813, -19669, -19527, -19386, -19245, -19109, -18970, -18835, -18700, -18566, -18434, -18303, -18172, -18045, -17918, -17788, -17664, -17539, -17417, -17294, -17173, -17053, -16934, -16816, -16698, -16582, -16468, -16354, -16240, -16128, -16018, -15907, -15798, -15691, -15584, -15477, -15371, -15269, -15165, -15063, -14962, -14859, -14762, -14662, -14564, -14469, -14372, -14277, -14182, -14089, -13997, -13905, -13813, -13724, -13636, -13546, -13460, -13372, -13286, -13201, -13117, -13034, -12950, -12866, -12691, -13111, -10881};