/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1538 256 samples */
 
const int16_t AKWF_1538_256_DATA [256] = 
{169, 470, 766, 1064, 1359, 1655, 1950, 2243, 2539, 2836, 3131, 3426, 3720, 4012, 4310, 4602, 4896, 5189, 5479, 5774, 6070, 6366, 6660, 6954, 7249, 7543, 7837, 8132, 8426, 8718, 9011, 9303, 9598, 9890, 10182, 10475, 10767, 11059, 11352, 11642, 11933, 12223, 12515, 12807, 13097, 13387, 13678, 13969, 14258, 14549, 14838, 15128, 15417, 15707, 15995, 16286, 16570, 16861, 17150, 17437, 17726, 18011, 18298, 18587, 18875, 19162, 19447, 19734, 20021, 20309, 20594, 20880, 21164, 21451, 21735, 22020, 22308, 22591, 22872, 23194, 22612, 27384, 11705, -23172, -18464, -19027, -18693, -18398, -18101, -17809, -17510, -17213, -16913, -16617, -16316, -16014, -15711, -15411, -15109, -14806, -14504, -14202, -13899, -13595, -13294, -12992, -12687, -12381, -12079, -11777, -11474, -11170, -10868, -10564, -10261, -9957, -9656, -9352, -9048, -8746, -8446, -8145, -7842, -7539, -7237, -6934, -6632, -6334, -6032, -5730, -5427, -5129, -4828, -4527, -4228, -3927, -3628, -3326, -3029, -2729, -2429, -2131, -1833, -1534, -1235, -936, -637, -342, -43, 254, 549, 847, 1145, 1440, 1738, 2036, 2330, 2628, 2922, 3216, 3514, 3810, 4104, 4400, 4694, 4989, 5281, 5576, 5871, 6165, 6457, 6750, 7046, 7337, 7631, 7923, 8216, 8509, 8801, 9094, 9386, 9675, 9968, 10260, 10551, 10842, 11132, 11425, 11909, 10792, 18145, -11041, -21072, -18365, -18446, -18154, -17859, -17560, -17260, -16960, -16661, -16361, -16059, -15758, -15458, -15155, -14852, -14551, -14248, -13944, -13644, -13340, -13039, -12735, -12434, -12131, -11827, -11524, -11222, -10919, -10617, -10313, -10010, -9708, -9408, -9106, -8803, -8501, -8199, -7899, -7597, -7298, -6995, -6694, -6394, -6093, -5792, -5493, -5193, -4891, -4594, -4296, -3994, -3694, -3398, -3099, -2801, -2501, -2202, -1904, -1607, -1308, -1013, -715, -418, -116};