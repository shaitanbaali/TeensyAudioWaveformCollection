/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1516 256 samples */
 
const int16_t AKWF_1516_256_DATA [256] = 
{5329, 6078, 7709, 7550, 7579, 7579, 7579, 7579, 7579, 7579, 7579, 7579, 7579, 7579, 7587, 7556, 7736, 10160, 12912, 19414, 19354, 19771, 19713, 19724, 19724, 19724, 19724, 19724, 19724, 19724, 19724, 19724, 19724, 19724, 19724, 19713, 19772, 19448, 19066, 19125, 19114, 19114, 19114, 19114, 19114, 19114, 19114, 19114, 19114, 19114, 19114, 19114, 19159, 18916, 20293, 21472, 27778, 31307, 32483, 32810, 32757, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32671, 33177, 28848, 26079, 19908, 18932, 19147, 19042, 19469, 7652, 3548, 103, -2, 6, 0, 0, 0, 0, -7, 1, -104, -3549, -7653, -19470, -19043, -19148, -18933, -19909, -26080, -28848, -33177, -32671, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32757, -32810, -32483, -31307, -27778, -21472, -20294, -18917, -19159, -19114, -19114, -19114, -19114, -19114, -19114, -19114, -19114, -19114, -19114, -19114, -19114, -19126, -19066, -19449, -19772, -19714, -19724, -19724, -19724, -19724, -19724, -19724, -19724, -19724, -19724, -19724, -19724, -19724, -19713, -19771, -19355, -19415, -12913, -10160, -7736, -7557, -7588, -7579, -7579, -7579, -7579, -7579, -7579, -7579, -7579, -7579, -7579, -7551, -7710, -6079, -5330};