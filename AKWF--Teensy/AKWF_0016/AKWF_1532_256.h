/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1532 256 samples */
 
const int16_t AKWF_1532_256_DATA [256] = 
{124, 409, 689, 970, 1249, 1533, 1813, 2093, 2373, 2654, 2934, 3213, 3492, 3773, 4053, 4331, 4611, 4924, 5213, 5493, 5773, 6054, 6333, 6610, 6892, 7170, 7450, 7729, 8007, 8287, 8564, 8843, 9122, 9399, 9675, 9954, 10231, 10507, 10786, 11062, 11339, 11615, 11892, 12168, 12444, 12718, 12995, 13272, 13546, 13821, 14093, 14370, 14644, 14918, 15193, 15471, 15741, 16016, 16289, 16563, 16833, 17108, 17381, 17654, 17928, 18200, 18472, 18742, 19014, 19286, 19561, 19826, 20099, 20372, 20642, 20912, 21183, 21452, 21724, 21993, 22262, 22534, 22802, 23070, 23341, 23611, 23878, 24147, 24415, 24684, 24952, 25220, 25489, 25756, 26021, 26290, 26558, 26825, 27090, 27356, 27624, 27890, 28155, 28421, 28688, 28952, 29217, 29483, 29750, 30012, 30277, 30543, 30805, 31070, 31341, 30837, 35401, 16784, -28337, -23231, -23912, -23593, -23315, -23037, -22758, -22475, -22195, -21913, -21626, -21340, -21055, -20769, -20480, -20192, -19903, -19615, -19326, -19037, -18748, -18459, -18167, -17875, -17588, -17298, -17006, -16714, -16425, -16136, -15843, -15553, -15265, -14974, -14684, -14392, -14102, -13813, -13523, -13233, -12944, -12656, -12365, -12077, -11788, -11499, -11209, -10921, -10631, -10344, -10056, -9495, -10608, -818, -21322, -24489, -23416, -23200, -22911, -22622, -22331, -22039, -21748, -21458, -21166, -20874, -20580, -20291, -19997, -19705, -19415, -19121, -18830, -18538, -18248, -17953, -17663, -17368, -17080, -16790, -16497, -16205, -15914, -15624, -15334, -15040, -14751, -14460, -14170, -13881, -13592, -13301, -13010, -12723, -12432, -12144, -11854, -11566, -11276, -10988, -10698, -10414, -10124, -9833, -9547, -9263, -8973, -8687, -8398, -8114, -7826, -7539, -7254, -6968, -6681, -6395, -6111, -5825, -5538, -5253, -4969, -4684, -4401, -4115, -3832, -3547, -3264, -2980, -2697, -2412, -2130, -1847, -1566, -1282, -998, -718, -436, -149};