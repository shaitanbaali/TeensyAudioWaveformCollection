/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1597 256 samples */
 
const int16_t AKWF_1597_256_DATA [256] = 
{17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17371, 17470, 16744, 19982, 28558, 14691, 15526, 15399, 15396, 15396, 15278, 15928, 13216, -93, -6, 21, 0, 0, 0, 0, -22, 5, 92, -13216, -15929, -15279, -15396, -15396, -15400, -15527, -14691, -28558, -19982, -16744, -17470, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371, -17371};