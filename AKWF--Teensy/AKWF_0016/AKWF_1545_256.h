/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1545 256 samples */
 
const int16_t AKWF_1545_256_DATA [256] = 
{775, 2473, 3748, 4826, 5714, 6440, 7044, 7541, 7954, 8290, 8568, 8796, 8985, 9139, 9266, 9370, 9455, 9524, 9580, 9626, 9664, 9691, 9716, 9734, 9748, 9761, 9769, 9774, 9778, 9780, 9780, 9780, 9778, 9777, 9774, 9770, 9766, 9763, 9759, 9754, 9749, 9744, 9739, 9734, 9728, 9722, 9718, 9712, 9706, 9702, 9695, 9690, 9685, 9679, 9671, 9667, 9661, 9653, 9649, 9643, 9637, 9631, 9625, 9619, 9614, 9609, 9603, 9597, 9590, 9584, 9578, 9574, 9568, 9562, 9556, 9549, 9544, 9539, 9533, 9528, 9522, 9515, 9509, 9503, 8841, 12403, -7150, -32826, -28873, -29633, -29621, -29618, -29613, -29607, -29598, -29590, -29581, -29571, -29560, -29547, -29536, -29523, -29511, -29498, -29484, -29470, -29455, -29440, -29432, -28830, -32034, -14744, 12523, 9094, 9763, 9745, 9752, 9756, 9761, 9765, 9769, 9770, 9770, 9770, 9770, 9769, 9767, 9767, 9765, 9762, 9758, 9757, 9753, 9749, 9745, 9741, 9736, 9732, 9728, 9724, 9718, 9714, 9709, 9703, 9698, 9694, 9689, 9682, 9678, 9673, 9666, 9660, 9657, 9649, 9644, 9638, 9634, 9626, 9621, 9616, 9610, 9603, 9599, 9594, 9586, 9581, 9575, 9569, 9563, 9557, 9553, 9547, 9541, 9535, 9528, 9523, 9519, 9513, 9507, 9500, 9494, 9489, 9485, 9478, 9472, 9466, 9460, 9456, 9448, 9444, 9438, 9432, 9425, 9420, 9416, 9407, 9403, 9397, 9391, 9385, 9379, 9375, 9368, 9347, 9103, 10708, -21561, -31414, -29247, -29641, -29635, -29632, -29627, -29619, -29612, -29603, -29592, -29583, -29571, -29560, -29547, -29534, -29522, -29509, -29495, -29480, -29465, -29450, -29435, -29420, -29404, -29389, -29367, -29298, -29543, -25535, -19068, -14125, -9945, -6491, -3661, -1307, 634, 2222, 3541, 4635, 5408, 6736, 4910, -21752, -19883, -13792, -9853, -6407, -3582, -1222};