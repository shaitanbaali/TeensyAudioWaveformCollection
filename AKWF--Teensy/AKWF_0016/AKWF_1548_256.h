/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1548 256 samples */
 
const int16_t AKWF_1548_256_DATA [256] = 
{522, 1436, 2079, 2626, 3078, 3448, 3753, 4005, 4213, 4384, 4525, 4641, 4737, 4814, 4879, 4932, 4975, 5010, 5039, 5061, 5079, 5094, 5106, 5115, 5122, 5128, 5131, 5134, 5135, 5136, 5136, 5136, 5134, 5134, 5131, 4747, 6885, -4491, -27585, -20405, -16180, -12459, -9378, -6844, -4740, -3017, -1585, -410, 563, 1368, 2030, 2571, 3026, 3395, 3702, 3955, 4164, 4333, 4475, 4593, 4688, 4765, 4829, 4882, 4926, 4961, 4989, 5011, 5031, 5046, 5057, 5066, 5074, 5079, 5082, 5084, 5086, 5087, 5087, 5087, 5086, 5085, 5083, 5081, 5080, 5078, 5075, 5071, 5070, 5068, 5065, 5061, 5059, 5056, 5053, 5050, 5048, 5044, 5041, 5039, 5035, 5031, 5028, 5024, 5021, 5018, 5015, 5012, 5010, 5006, 5001, 4999, 4997, 4993, 4990, 4987, 4984, 4981, 4978, 4975, 4972, 4969, 4964, 4961, 4958, 4955, 4951, 4949, 4923, 4480, 7091, -19417, -35072, -32234, -32755, -32756, -32750, -32742, -32733, -32723, -32713, -32700, -32688, -32675, -32662, -32648, -32632, -32618, -32603, -32587, -32570, -32554, -32538, -32435, -32559, -32345, -3078, 6918, 4841, 5252, 5257, 5265, 5271, 5279, 5286, 5289, 5292, 5296, 5299, 5301, 5301, 5302, 5303, 5303, 5303, 5303, 5303, 5301, 5299, 5299, 5297, 5294, 5293, 5291, 5288, 5287, 5284, 5281, 5279, 5276, 5273, 5270, 5267, 5265, 5263, 5259, 5256, 5254, 5251, 5247, 5244, 5242, 5238, 5235, 5232, 5229, 5226, 5223, 5219, 5216, 5215, 5209, 5205, 5204, 5200, 5195, 5193, 5190, 5187, 5184, 5181, 5177, 5175, 5171, 5167, 5165, 5161, 5158, 5156, 5153, 5148, 5145, 5141, 5138, 5135, 5132, 5128, 5126, 5123, 5119, 5117, 5113, 5113, 4625, 7383, -7024, -29036, -20384, -16413, -12638, -9538, -6983, -4862, -3115, -1680, -472};