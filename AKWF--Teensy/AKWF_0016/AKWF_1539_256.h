/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1539 256 samples */
 
const int16_t AKWF_1539_256_DATA [256] = 
{141, 395, 645, 894, 1142, 1393, 1640, 1888, 2136, 2386, 2634, 2882, 3128, 3377, 3626, 3872, 4119, 4366, 4613, 4860, 5106, 5353, 5601, 5846, 6088, 6368, 6633, 6878, 7124, 7371, 7618, 7863, 8111, 8357, 8602, 8849, 9094, 9339, 9585, 9830, 10075, 10321, 10566, 10811, 11054, 11299, 11544, 11788, 12032, 12276, 12519, 12763, 13006, 13250, 13495, 13735, 13977, 14222, 14465, 14706, 14947, 15189, 15432, 15674, 15915, 16157, 16398, 16639, 16880, 17120, 17360, 17602, 17965, 17226, 22248, -7919, -18028, -15505, -15637, -15389, -15142, -14893, -14643, -14393, -14141, -13889, -13637, -13384, -13129, -12876, -12623, -12369, -12115, -11862, -11606, -11351, -11095, -10841, -10587, -10330, -10076, -9820, -9564, -9309, -9056, -8800, -8545, -8290, -8035, -7782, -7526, -7272, -7017, -6761, -6507, -6256, -6001, -5747, -5493, -5239, -4987, -4734, -4479, -4228, -3975, -3720, -3469, -3218, -2964, -2712, -2459, -2209, -1957, -1706, -1454, -1202, -951, -700, -451, -199, 52, 300, 550, 800, 1049, 1300, 1549, 1798, 2049, 2298, 2546, 2795, 3044, 3291, 3539, 3789, 4036, 4284, 4530, 4777, 5027, 5273, 5521, 5767, 6014, 6260, 6508, 6754, 7001, 7245, 7491, 7738, 7985, 8229, 8473, 8719, 8964, 9207, 9454, 9699, 9940, 10186, 10429, 10674, 10919, 11161, 11405, 11649, 11891, 12283, 11623, 16998, -11116, -16929, -15289, -15253, -15007, -14757, -14506, -14256, -14004, -13753, -13500, -13248, -12996, -12742, -12488, -12234, -11981, -11727, -11471, -11217, -10964, -10710, -10454, -10200, -9944, -9691, -9439, -9183, -8928, -8673, -8420, -8166, -7911, -7659, -7404, -7149, -6896, -6644, -6390, -6137, -5883, -5629, -5379, -5125, -4872, -4621, -4368, -4114, -3863, -3612, -3360, -3107, -2857, -2606, -2355, -2103, -1852, -1602, -1350, -1100, -852, -600, -351, -97};