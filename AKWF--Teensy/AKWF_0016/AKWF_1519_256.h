/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1519 256 samples */
 
const int16_t AKWF_1519_256_DATA [256] = 
{299, 923, 1522, 2063, 2456, 2841, 3251, 3677, 4121, 4583, 5058, 5550, 6056, 6574, 7105, 7647, 8200, 8765, 9338, 9919, 10509, 11106, 11709, 12319, 12933, 13552, 14176, 14802, 15429, 16060, 16690, 17321, 17952, 18581, 19208, 19833, 20454, 21072, 21685, 22292, 22894, 23490, 24076, 24656, 25226, 25787, 26337, 26877, 27404, 27921, 28424, 28912, 29387, 29847, 30290, 30717, 31126, 31516, 31886, 32240, 32545, 32681, 32743, 32768, 32757, 32709, 32624, 32414, 32076, 31723, 31348, 30955, 30544, 30113, 29667, 29202, 28721, 28226, 27715, 27192, 26657, 26109, 25552, 24985, 24409, 23823, 23232, 22631, 22025, 21415, 20797, 20178, 19555, 18927, 18301, 17671, 17040, 16411, 15782, 15153, 14528, 13905, 13285, 12672, 12062, 11457, 10860, 10269, 9685, 9111, 8545, 7988, 7443, 6909, 6386, 5877, 5380, 4898, 4432, 3981, 3549, 3142, 2748, 2380, 2000, 1474, 892, 299, -300, -893, -1475, -2001, -2381, -2749, -3143, -3550, -3982, -4433, -4899, -5381, -5878, -6387, -6909, -7444, -7989, -8545, -9111, -9686, -10270, -10861, -11457, -12062, -12672, -13286, -13906, -14529, -15154, -15782, -16411, -17040, -17671, -18301, -18928, -19555, -20178, -20797, -21415, -22025, -22631, -23232, -23824, -24409, -24985, -25552, -26109, -26657, -27192, -27715, -28226, -28721, -29202, -29667, -30113, -30544, -30956, -31348, -31723, -32076, -32414, -32624, -32709, -32757, -32768, -32743, -32681, -32545, -32240, -31886, -31516, -31126, -30717, -30290, -29847, -29387, -28912, -28424, -27921, -27405, -26878, -26337, -25787, -25227, -24656, -24076, -23490, -22895, -22292, -21685, -21072, -20455, -19834, -19208, -18581, -17952, -17321, -16690, -16061, -15430, -14802, -14177, -13553, -12933, -12319, -11709, -11106, -10510, -9920, -9339, -8765, -8200, -7648, -7106, -6574, -6057, -5550, -5059, -4584, -4122, -3678, -3252, -2842, -2457, -2064, -1523, -924, -300};