/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1543 256 samples */
 
const int16_t AKWF_1543_256_DATA [256] = 
{2883, 12850, 20704, 25986, 28519, 28824, 28203, 26704, 25394, 24735, 24503, 24341, 24404, 24445, 24486, 24539, 24529, 24426, 24333, 24238, 24141, 24045, 23952, 23840, 23657, 23520, 23541, 23479, 23346, 23254, 23226, 23055, 22918, 22876, 22858, 22749, 22655, 22553, 22481, 22423, 22322, 22226, 22132, 22029, 21968, 21963, 21889, 21704, 21624, 21533, 21509, 21400, 21310, 21308, 21251, 21090, 20931, 20930, 20866, 20761, 20666, 20569, 20475, 20371, 20317, 20280, 20145, 20002, 19905, 19893, 19816, 19714, 19618, 19508, 19236, 18202, 13924, 6558, -1861, -10170, -15706, -18408, -19221, -18399, -17104, -15936, -14688, -13899, -13539, -13349, -13176, -12982, -12916, -12834, -12494, -12220, -11942, -11655, -11408, -11249, -11044, -10739, -10464, -10274, -10070, -9779, -9522, -9331, -9092, -8796, -8544, -8435, -8186, -7979, -7829, -7609, -7369, -7079, -6855, -6705, -6497, -6290, -6132, -5939, -5805, -5564, -5377, -5297, -5026, -4798, -4638, -4468, -4298, -4136, -3930, -3785, -3604, -3434, -3300, -3093, -2849, -2673, -2509, -2389, -2228, -2053, -1907, -1817, -1617, -1441, -1267, -1142, -1092, -938, -765, -601, -502, -411, -222, -125, 59, 227, 316, 442, 493, 594, 800, 977, 1069, 1105, 1246, 1431, 1513, 1646, 1876, 1945, 2091, 2191, 2249, 2348, 2437, 2522, 2647, 2830, 2939, 2951, 3163, 3225, 3256, 3359, 3446, 3535, 3619, 3704, 3564, 1759, -2863, -10084, -18252, -25028, -29735, -32191, -32794, -32235, -30859, -29478, -28283, -27329, -26663, -26364, -26106, -25766, -25489, -25157, -24803, -24407, -23958, -23607, -23263, -22811, -22418, -22044, -21692, -21393, -21020, -20628, -20279, -19925, -19518, -19183, -18870, -18502, -18188, -17857, -17521, -17249, -16908, -16550, -16199, -15838, -15539, -15231, -14861, -14609, -14355, -13999, -13714, -13407, -13055, -12771, -12502, -12205, -11863, -11294, -9397, -4609};