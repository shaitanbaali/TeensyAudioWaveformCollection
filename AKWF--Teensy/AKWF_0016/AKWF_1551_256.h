/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1551 256 samples */
 
const int16_t AKWF_1551_256_DATA [256] = 
{332, 1205, 1900, 2478, 2950, 3345, 3666, 3933, 4152, 4334, 4484, 4606, 4706, 4789, 4856, 4912, 4956, 4994, 5024, 5047, 5068, 5083, 5095, 5104, 5111, 5116, 5121, 5124, 5126, 5127, 5127, 5126, 5125, 5123, 5122, 5120, 5118, 5114, 5111, 5108, 5107, 5102, 5100, 5098, 5093, 5090, 5087, 5083, 5082, 5078, 5074, 5070, 5067, 5063, 5060, 5057, 5053, 5050, 5046, 5043, 5040, 5035, 5032, 5028, 5024, 5022, 5018, 5014, 5011, 5007, 5004, 5002, 4999, 4994, 4990, 4987, 4984, 4980, 4976, 4973, 4972, 4392, 7533, -11621, -35240, -32198, -32758, -32759, -32754, -32747, -32738, -32727, -32717, -32707, -32696, -32684, -32670, -32655, -32641, -32627, -32611, -32596, -32581, -32565, -32548, -32531, -31986, -34879, -16289, 7890, 4659, 5280, 5271, 5279, 5286, 5292, 5299, 5303, 5307, 5310, 5313, 5315, 5316, 5317, 5318, 5317, 5316, 5316, 5315, 5314, 5313, 5310, 5308, 5307, 5304, 5302, 5299, 5297, 5294, 5292, 5288, 5286, 5283, 5280, 5277, 5274, 5271, 5268, 5265, 5260, 5256, 5254, 5251, 5247, 5245, 5242, 5238, 5234, 5231, 5228, 5224, 5220, 5217, 5213, 5211, 5207, 5203, 5199, 5196, 5193, 5188, 5185, 5182, 5178, 5175, 5171, 5168, 5165, 5159, 4960, 5984, 2015, -25326, -22947, -17334, -13597, -10299, -7595, -5370, -3527, -2016, -702, 495, 1331, 2030, 2602, 3077, 3468, 3792, 4056, 4275, 4455, 4605, 4726, 4828, 4909, 4975, 5032, 5076, 5113, 5143, 5166, 5186, 5202, 5214, 5224, 5231, 5235, 5240, 5243, 5244, 5245, 5245, 5245, 5245, 5242, 5238, 5238, 5235, 5232, 5229, 5228, 5224, 5221, 5217, 5214, 5211, 5208, 5205, 5201, 5198, 5194, 5190, 4968, 6136, 694, -26224, -22517, -17163, -13406, -10139, -7451, -5249, -3416, -1917, -656};