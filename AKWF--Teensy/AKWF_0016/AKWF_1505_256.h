/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1505 256 samples */
 
const int16_t AKWF_1505_256_DATA [256] = 
{1424, 1474, 1202, 3103, 4524, 4059, 5340, 7275, 7044, 7331, 9672, 10053, 9916, 10955, 12185, 12861, 13924, 14247, 14551, 15759, 16899, 17174, 16927, 18045, 20057, 19942, 19852, 20957, 21364, 22225, 22789, 23377, 24332, 24220, 24127, 24980, 26795, 27127, 27051, 27083, 27020, 27279, 29619, 29987, 29902, 29919, 29919, 29946, 29806, 30664, 31355, 31845, 32873, 32744, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32767, 32751, 32842, 31707, 31264, 31361, 31343, 31343, 31343, 31320, 31447, 30428, 29820, 29942, 29919, 29897, 30009, 29011, 27254, 27002, 27188, 26503, 25535, 25645, 25751, 24873, 24228, 23620, 22766, 21794, 21266, 21472, 20964, 19745, 18603, 18504, 17288, 17019, 17242, 16228, 14168, 14296, 14082, 12940, 12344, 11138, 10004, 9986, 9900, 7603, 7004, 7226, 6761, 4429, 4225, 4338, 3025, 1434, 1493, 937, -938, -1494, -1435, -3026, -4339, -4226, -4430, -6762, -7227, -7004, -7604, -9901, -9987, -10004, -11139, -12344, -12941, -14083, -14296, -14169, -16228, -17242, -17019, -17288, -18504, -18604, -19745, -20964, -21472, -21266, -21794, -22766, -23620, -24228, -24873, -25752, -25645, -25535, -26503, -27188, -27002, -27254, -29011, -30009, -29897, -29919, -29942, -29820, -30428, -31447, -31320, -31343, -31343, -31343, -31361, -31265, -31707, -32842, -32751, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32744, -32873, -31845, -31355, -30664, -29806, -29946, -29919, -29919, -29902, -29987, -29619, -27279, -27020, -27084, -27052, -27127, -26795, -24980, -24127, -24220, -24332, -23377, -22789, -22226, -21365, -20957, -19852, -19943, -20057, -18045, -16927, -17174, -16900, -15760, -14552, -14247, -13924, -12862, -12185, -10956, -9917, -10053, -9673, -7332, -7044, -7276, -5340, -4060, -4525, -3104, -1203, -1475, -1424};