/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_violin_0007 256 samples */
 
const int16_t AKWF_violin_0007_256_DATA [256] = 
{167, 1525, 3157, 3972, 4392, 4758, 5296, 6052, 6893, 8059, 9753, 11751, 13759, 15610, 17254, 18623, 19695, 20509, 21149, 21696, 22333, 23213, 24278, 25433, 26652, 27949, 29213, 30325, 31264, 32089, 32610, 32766, 32765, 32697, 32420, 31967, 31479, 30663, 29313, 27455, 25274, 22700, 19780, 16664, 13485, 10349, 7242, 4120, 1283, -1268, -3677, -5794, -7633, -9206, -10536, -11632, -12222, -12170, -11843, -11322, -10663, -9987, -9413, -9060, -8954, -9032, -9158, -9546, -10335, -10937, -11449, -12109, -12874, -13609, -14207, -14948, -16478, -18058, -19419, -21034, -22893, -24063, -24032, -23419, -21698, -18724, -14998, -11256, -7387, -3280, 592, 3014, 4084, 4279, 3268, 978, -2382, -6216, -9465, -12250, -14825, -16810, -17681, -17588, -16803, -14879, -12418, -10064, -7876, -5449, -3018, -1127, 148, 1297, 2305, 2598, 1837, 758, -402, -2554, -5651, -8926, -11838, -14787, -17329, -19173, -20477, -21198, -20934, -19679, -18218, -16586, -14745, -12929, -11841, -11090, -10345, -9988, -9956, -10261, -10760, -10887, -10503, -9826, -9090, -8006, -6792, -5637, -4275, -3158, -2401, -1733, -1036, -815, -1190, -1648, -2659, -3944, -4884, -5430, -5220, -4005, -1916, 402, 2683, 4933, 6973, 8422, 9084, 9118, 8960, 8861, 8889, 9048, 9434, 10071, 11003, 12341, 13743, 14911, 15827, 16650, 17456, 18150, 18555, 18969, 19250, 19094, 18800, 18532, 18368, 18373, 18685, 19168, 19647, 20186, 20638, 20924, 21079, 21073, 21014, 20959, 20836, 20914, 21125, 21175, 20986, 20333, 19169, 17603, 15530, 13064, 10457, 7950, 5689, 3647, 1772, -13, -1618, -3031, -4367, -5443, -6284, -7002, -7437, -8003, -9034, -10486, -12217, -14236, -16628, -19267, -22035, -24733, -27107, -28930, -30210, -30976, -31219, -30964, -30356, -29532, -28513, -27426, -26309, -25083, -23680, -22006, -19998, -17592, -14896, -12093, -9187, -6029, -2939, -669};