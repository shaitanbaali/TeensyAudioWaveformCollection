/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_violin_0006 256 samples */
 
const int16_t AKWF_violin_0006_256_DATA [256] = 
{894, 3183, 6017, 8897, 11765, 14593, 17318, 19919, 22406, 24830, 27071, 28942, 30446, 31588, 32344, 32704, 32777, 32652, 32195, 31363, 30222, 29069, 27838, 26444, 25159, 23927, 22819, 21966, 21310, 20781, 20228, 19471, 18474, 17431, 16234, 14701, 12897, 10974, 8988, 7033, 5320, 3946, 2789, 1670, 544, -493, -1478, -2369, -3021, -3364, -3387, -3180, -2848, -2364, -1651, -810, -95, 372, 544, 464, 200, -241, -992, -2144, -3653, -5358, -7056, -8674, -10229, -11732, -13229, -14702, -16122, -17522, -18788, -19869, -20787, -21579, -22359, -23134, -23830, -24371, -24869, -25115, -25005, -24922, -24823, -24834, -25041, -25253, -25605, -25795, -25590, -25295, -24932, -24464, -23828, -22990, -22002, -20881, -19497, -17706, -15673, -13491, -11131, -8656, -6289, -4042, -1919, -44, 1646, 3236, 4797, 6372, 7823, 9082, 10213, 11265, 12081, 12733, 13230, 13560, 13951, 14344, 14809, 15564, 16546, 17743, 19092, 20476, 21814, 23024, 24015, 24699, 25026, 25176, 25160, 24964, 24877, 24759, 24632, 24646, 24743, 24910, 25098, 25241, 25296, 25264, 25045, 24610, 24110, 23448, 22642, 21775, 20847, 19870, 18950, 18198, 17592, 17025, 16483, 15963, 15380, 14664, 13793, 12736, 11484, 10113, 8618, 7034, 5470, 3898, 2363, 1003, -121, -1175, -2333, -3631, -4941, -6253, -7527, -8824, -10206, -11415, -12399, -13263, -14085, -14855, -15704, -16675, -17684, -18704, -19848, -21030, -22030, -22729, -23252, -23453, -23202, -22890, -22392, -21784, -21356, -21148, -20968, -20905, -21079, -21159, -20785, -20188, -19616, -18749, -17871, -17271, -16877, -16394, -15992, -15801, -15679, -15457, -15628, -15991, -16036, -15621, -14656, -13463, -12259, -10928, -9489, -8168, -7159, -6489, -6266, -6592, -7417, -8534, -9744, -10577, -10927, -11125, -11043, -10720, -10351, -10087, -9880, -9913, -10049, -9901, -9544, -9193, -8674, -7691, -6525, -5099, -3183, -903};