/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_violin_0004 256 samples */
 
const int16_t AKWF_violin_0004_256_DATA [256] = 
{1101, 3944, 6450, 9488, 12659, 15642, 18503, 21330, 23926, 26113, 28228, 30065, 31299, 32089, 32642, 32799, 32567, 31840, 30881, 29680, 28089, 26349, 24661, 22819, 20729, 18757, 16875, 14912, 13021, 11402, 10316, 9748, 9537, 9631, 9801, 9719, 9258, 8377, 6946, 5180, 3317, 1413, -545, -2447, -4228, -5822, -7219, -8522, -9764, -11110, -12637, -14347, -16205, -17972, -19561, -20820, -21627, -22048, -22241, -22251, -22118, -21882, -21576, -21383, -21324, -21361, -21546, -21940, -22364, -22665, -23023, -23664, -24403, -25102, -25595, -25782, -25577, -24773, -23416, -21610, -19476, -17194, -14829, -12352, -9866, -7566, -5513, -3675, -2088, -925, -259, 23, -89, -521, -1228, -2173, -3182, -4195, -5079, -5629, -5677, -5238, -4425, -3305, -1998, -659, 759, 2237, 3769, 5355, 6965, 8453, 9801, 11015, 11992, 12629, 13084, 13386, 13492, 13410, 13285, 13366, 13728, 14333, 15179, 16278, 17429, 18657, 19934, 21100, 22137, 22966, 23537, 23889, 24049, 23980, 23799, 23606, 23415, 23223, 23065, 22845, 22628, 22500, 22294, 21923, 21485, 20982, 20301, 19467, 18575, 17666, 16722, 15779, 14996, 14248, 13486, 12717, 11901, 10995, 9980, 8784, 7313, 5570, 3649, 1588, -518, -2617, -4745, -6765, -8663, -10415, -12032, -13588, -15051, -16348, -17424, -18337, -19218, -19970, -20533, -21009, -21529, -22096, -22696, -23265, -23820, -24328, -24518, -24573, -24335, -23733, -23049, -22096, -21036, -20028, -19051, -18119, -17418, -16773, -16164, -15687, -15222, -14839, -14520, -14032, -13352, -12834, -12144, -11396, -10591, -9549, -8588, -7576, -6883, -6604, -6272, -5873, -5659, -5244, -4424, -3660, -2892, -1870, -854, -453, -743, -1104, -1886, -3121, -4467, -5907, -6869, -7107, -6778, -5886, -4240, -2577, -796, 1035, 2450, 3743, 4907, 5410, 5202, 4751, 3945, 2924, 2179, 1650, 754, -203, -1035, -1653, -1977, -1440};