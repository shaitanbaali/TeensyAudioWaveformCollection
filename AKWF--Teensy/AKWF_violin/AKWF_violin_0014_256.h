/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_violin_0014 256 samples */
 
const int16_t AKWF_violin_0014_256_DATA [256] = 
{337, 1307, 2198, 2998, 3715, 4365, 4965, 5539, 6106, 6662, 7207, 7736, 8245, 8728, 9188, 9629, 10050, 10453, 10838, 11204, 11556, 11891, 12211, 12515, 12803, 13079, 13344, 13595, 13835, 14066, 14285, 14499, 14706, 14909, 15110, 15308, 15505, 15701, 15897, 16090, 16285, 16478, 16671, 16861, 17049, 17231, 17409, 17583, 17754, 17924, 18091, 18254, 18413, 18566, 18713, 18851, 18979, 19099, 19209, 19312, 19405, 19491, 19568, 19637, 19700, 19759, 19813, 19862, 19906, 19943, 19977, 20006, 20029, 20046, 20060, 20071, 20079, 20084, 20087, 20090, 20097, 20108, 20125, 20145, 20169, 20196, 20221, 20246, 20272, 20297, 20322, 20347, 20373, 20399, 20424, 20451, 20483, 20519, 20560, 20601, 20640, 20674, 20697, 20709, 20712, 20706, 20695, 20678, 20657, 20629, 20592, 20542, 20476, 20391, 20288, 20164, 20018, 19851, 19658, 19439, 19192, 18920, 18621, 18292, 17937, 17552, 17136, 16691, 16210, 15696, 15150, 14571, 13966, 13336, 12673, 11987, 11274, 10534, 9774, 8981, 8163, 7325, 6462, 5581, 4690, 3773, 2843, 1903, 950, -4, -965, -1935, -2908, -3882, -4860, -5831, -6805, -7780, -8748, -9714, -10673, -11623, -12569, -13503, -14419, -15318, -16194, -17054, -17894, -18713, -19510, -20284, -21035, -21764, -22468, -23146, -23794, -24421, -25022, -25597, -26150, -26675, -27175, -27657, -28113, -28546, -28958, -29344, -29711, -30057, -30380, -30680, -30959, -31216, -31452, -31671, -31869, -32048, -32208, -32350, -32473, -32576, -32658, -32721, -32760, -32768, -32768, -32745, -32689, -32607, -32495, -32351, -32172, -31959, -31711, -31425, -31101, -30736, -30331, -29885, -29405, -28884, -28329, -27740, -27119, -26466, -25776, -25053, -24300, -23516, -22709, -21875, -21018, -20142, -19251, -18348, -17434, -16513, -15587, -14663, -13740, -12824, -11904, -10992, -10078, -9169, -8278, -7402, -6546, -5723, -4927, -4137, -3333, -2485, -1582, -607};