/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_violin_0002 256 samples */
 
const int16_t AKWF_violin_0002_256_DATA [256] = 
{639, 2652, 5182, 7341, 9070, 10535, 11831, 13135, 14607, 16209, 17906, 19815, 21649, 23100, 24090, 24702, 25199, 25711, 26042, 26339, 26796, 27504, 28449, 29396, 30487, 31472, 32230, 32679, 32767, 32640, 32284, 31561, 30484, 29071, 27247, 25091, 22831, 20426, 17841, 14979, 11937, 8891, 5868, 2934, 339, -2168, -4469, -6612, -8915, -11298, -13630, -15905, -18065, -20082, -21812, -23175, -24253, -25043, -25768, -26416, -27013, -27759, -28643, -29418, -30107, -30496, -30596, -30308, -29345, -27725, -25784, -23476, -20943, -18153, -15185, -12309, -9593, -6881, -4550, -2590, -844, 639, 1675, 2198, 2526, 2941, 3370, 3923, 4703, 5630, 6675, 7581, 8445, 9352, 10180, 10734, 10981, 10988, 10485, 9598, 8383, 6905, 5669, 5042, 4645, 4579, 5015, 5316, 5078, 4608, 3655, 1607, -702, -2989, -5708, -8829, -11831, -14526, -17006, -19107, -20452, -20923, -20874, -20457, -19419, -18371, -17990, -17650, -17565, -18099, -18441, -18882, -19074, -18285, -16745, -14627, -11449, -7240, -2638, 1543, 5983, 10556, 14304, 17111, 19312, 20645, 20993, 20622, 19999, 19067, 17660, 16368, 15446, 14479, 14131, 14559, 15286, 16673, 18588, 20530, 22583, 24564, 26127, 27045, 27137, 27023, 26815, 26348, 25623, 24631, 23222, 21468, 19659, 17537, 15133, 12687, 9823, 6336, 3033, -182, -3140, -5642, -7444, -8615, -9590, -10238, -10514, -10746, -11015, -11477, -12378, -13556, -14936, -16161, -17268, -17996, -18078, -17907, -17792, -17419, -16827, -15948, -14984, -14059, -13029, -12188, -11278, -10344, -9306, -8112, -6881, -5603, -4411, -3645, -3059, -2667, -2458, -2093, -1711, -1610, -1660, -2026, -2668, -3343, -4071, -4894, -5838, -6625, -7089, -7197, -6825, -5957, -4898, -3998, -3378, -3293, -3739, -4664, -6230, -8087, -10357, -12800, -15261, -17706, -19693, -20848, -21144, -20616, -19438, -17771, -15619, -13099, -10444, -7618, -4748, -1741};