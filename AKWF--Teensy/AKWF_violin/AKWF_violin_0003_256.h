/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_violin_0003 256 samples */
 
const int16_t AKWF_violin_0003_256_DATA [256] = 
{1365, 4425, 7577, 10926, 14169, 17048, 19801, 22575, 24996, 27021, 28910, 30526, 31779, 32558, 32750, 32438, 31927, 30973, 29501, 27646, 25542, 23423, 21228, 19004, 16888, 14843, 12833, 10997, 9480, 8403, 7799, 7502, 7458, 7537, 7467, 7081, 6507, 5645, 4525, 3274, 1882, 336, -1405, -3133, -4781, -6451, -7794, -9115, -10592, -12197, -14100, -16326, -18476, -20376, -22100, -23485, -24475, -24883, -24749, -24321, -23707, -22927, -22153, -21527, -21107, -20913, -20932, -21063, -21271, -21558, -21842, -22072, -22250, -22354, -22255, -21761, -20809, -19472, -17760, -15769, -13879, -11935, -9954, -8009, -6028, -4044, -2358, -991, 26, 510, 476, 159, -297, -768, -1186, -1719, -2270, -2662, -2792, -2646, -2289, -1637, -711, 304, 1279, 2244, 3221, 4294, 5501, 6754, 8065, 9370, 10652, 11831, 12745, 13474, 13898, 14030, 13999, 13828, 13584, 13564, 13846, 14397, 15347, 16517, 17862, 19309, 20725, 22024, 23216, 24263, 25049, 25533, 25780, 25635, 25197, 24633, 24001, 23338, 22725, 22145, 21545, 20958, 20439, 19871, 19272, 18679, 18005, 17166, 16211, 15097, 13854, 12602, 11338, 10209, 9240, 8365, 7530, 6591, 5529, 4342, 2961, 1386, -264, -1989, -3913, -6045, -8276, -10492, -12602, -14572, -16329, -17858, -19248, -20515, -21604, -22447, -22978, -23270, -23413, -23411, -23289, -23181, -23164, -22977, -22639, -22318, -21874, -21372, -20942, -20488, -19824, -18992, -18224, -17350, -16375, -15515, -14737, -14160, -13653, -13067, -12440, -11793, -10997, -10313, -9842, -9305, -8563, -7789, -6984, -6089, -5268, -4742, -4356, -3970, -3672, -3423, -2797, -1939, -849, 304, 1051, 1283, 1121, 519, -525, -1819, -3263, -4975, -6375, -6918, -6843, -6543, -5505, -3905, -2307, -701, 816, 1848, 2480, 3062, 3529, 3621, 3312, 2782, 2123, 1230, 168, -710, -1664, -2895, -3684, -3663, -2987, -1292};