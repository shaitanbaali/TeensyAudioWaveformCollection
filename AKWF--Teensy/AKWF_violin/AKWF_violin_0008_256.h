/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_violin_0008 256 samples */
 
const int16_t AKWF_violin_0008_256_DATA [256] = 
{583, 2057, 3471, 4741, 5486, 5825, 6002, 5997, 5770, 5546, 5696, 6239, 7102, 8154, 9242, 10402, 11537, 12422, 13025, 13347, 13398, 13214, 12820, 12471, 12549, 12868, 13458, 14443, 15663, 16852, 17849, 18697, 19510, 20245, 20769, 21039, 21163, 21298, 21538, 21843, 22309, 23028, 23735, 24299, 24578, 24375, 23744, 22813, 21675, 20265, 18738, 17181, 15407, 13545, 11661, 9763, 8041, 6494, 5009, 3545, 1991, 466, -827, -2197, -3771, -5523, -7450, -9626, -11987, -14334, -16535, -18677, -20833, -22559, -23918, -25209, -26544, -27608, -28338, -28918, -29474, -29887, -29959, -29624, -28785, -27454, -25671, -23438, -20881, -18060, -14906, -11785, -9001, -6707, -4678, -3011, -1832, -911, 284, 1968, 3951, 6122, 8322, 10388, 12069, 13426, 14419, 14878, 14918, 14822, 14825, 14940, 15067, 15301, 15939, 16945, 18196, 19677, 21662, 23669, 25375, 27054, 28727, 30162, 31147, 31724, 32275, 32758, 32505, 31891, 31098, 30003, 28783, 27554, 26328, 24992, 23590, 22270, 21115, 19849, 18419, 16928, 15449, 13609, 11404, 9268, 7165, 5126, 3252, 1738, 405, -860, -1932, -2811, -3662, -4641, -5690, -6884, -8199, -9504, -10755, -11845, -12629, -12989, -12993, -12839, -12752, -13130, -13986, -15074, -16461, -18227, -20346, -22565, -24343, -25414, -25800, -25376, -24275, -22743, -20912, -18641, -16286, -14545, -13309, -12792, -13050, -13541, -14120, -15006, -16382, -17508, -18330, -18917, -18553, -17576, -16352, -14766, -12581, -9993, -7451, -5442, -3362, -1108, 385, 1354, 2143, 2755, 2719, 2298, 1585, 27, -2211, -4882, -7798, -10727, -13638, -16395, -18429, -19372, -19482, -19317, -18791, -17729, -16189, -14621, -13381, -12386, -11346, -10385, -10015, -10396, -10818, -11186, -11688, -12423, -12925, -13007, -12736, -12148, -11203, -10088, -9207, -8507, -7743, -6821, -6075, -5767, -5823, -5830, -5470, -4797, -4026, -3065, -1983, -768};