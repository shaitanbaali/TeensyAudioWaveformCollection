/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_violin_0011 256 samples */
 
const int16_t AKWF_violin_0011_256_DATA [256] = 
{112, 365, 653, 1006, 1424, 1877, 2338, 2821, 3345, 3911, 4482, 5041, 5587, 6113, 6620, 7150, 7744, 8392, 9001, 9532, 10015, 10481, 10939, 11407, 11898, 12406, 12935, 13474, 13984, 14421, 14823, 15278, 15803, 16341, 16842, 17317, 17804, 18320, 18850, 19399, 19965, 20540, 21113, 21698, 22311, 22944, 23565, 24146, 24701, 25256, 25821, 26387, 26957, 27524, 28079, 28617, 29128, 29595, 30019, 30408, 30765, 31097, 31407, 31695, 31955, 32188, 32381, 32519, 32602, 32661, 32716, 32759, 32766, 32732, 32676, 32615, 32539, 32427, 32271, 32097, 31935, 31770, 31548, 31242, 30897, 30575, 30271, 29926, 29508, 29047, 28591, 28145, 27666, 27113, 26514, 25916, 25325, 24712, 24044, 23327, 22605, 21888, 21158, 20404, 19618, 18812, 17997, 17166, 16314, 15452, 14577, 13703, 12835, 11987, 11149, 10298, 9395, 8471, 7592, 6772, 5954, 5090, 4191, 3304, 2454, 1615, 778, -54, -868, -1648, -2424, -3247, -4108, -4950, -5734, -6482, -7256, -8068, -8879, -9670, -10450, -11244, -12070, -12904, -13727, -14540, -15324, -16074, -16814, -17564, -18318, -19052, -19744, -20400, -21020, -21599, -22135, -22625, -23079, -23524, -23962, -24373, -24739, -25059, -25343, -25595, -25798, -25937, -26028, -26122, -26246, -26396, -26566, -26751, -26932, -27093, -27250, -27425, -27628, -27875, -28187, -28541, -28898, -29242, -29580, -29920, -30261, -30611, -30971, -31309, -31592, -31817, -32003, -32156, -32267, -32329, -32336, -32261, -32085, -31823, -31513, -31162, -30742, -30232, -29641, -28981, -28265, -27492, -26684, -25841, -24958, -24043, -23108, -22172, -21247, -20319, -19394, -18465, -17542, -16630, -15730, -14845, -13981, -13141, -12335, -11571, -10851, -10185, -9579, -9037, -8531, -8034, -7543, -7080, -6649, -6256, -5910, -5608, -5324, -5036, -4752, -4483, -4228, -3963, -3665, -3352, -3069, -2827, -2560, -2209, -1791, -1374, -983, -635, -349, -111};