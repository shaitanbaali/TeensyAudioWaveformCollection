/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_violin_0009 256 samples */
 
const int16_t AKWF_violin_0009_256_DATA [256] = 
{964, 2453, 3900, 5270, 6569, 7821, 9037, 10187, 11267, 12275, 13208, 14074, 14841, 15477, 16002, 16459, 16855, 17190, 17456, 17651, 17775, 17830, 17822, 17758, 17648, 17513, 17365, 17182, 16937, 16633, 16298, 15951, 15577, 15165, 14726, 14292, 13888, 13508, 13140, 12792, 12455, 12123, 11821, 11581, 11418, 11299, 11200, 11153, 11211, 11393, 11666, 12003, 12415, 12913, 13503, 14171, 14901, 15692, 16576, 17546, 18567, 19585, 20595, 21624, 22674, 23736, 24810, 25880, 26921, 27919, 28851, 29702, 30456, 31124, 31710, 32187, 32520, 32704, 32768, 32727, 32583, 32326, 31963, 31478, 30861, 30132, 29320, 28432, 27453, 26363, 25181, 23963, 22716, 21416, 20043, 18618, 17225, 15896, 14564, 13154, 11701, 10305, 9028, 7829, 6675, 5571, 4553, 3638, 2802, 2009, 1263, 612, 86, -339, -701, -1005, -1242, -1407, -1505, -1539, -1512, -1439, -1338, -1194, -958, -621, -247, 109, 449, 791, 1140, 1487, 1820, 2153, 2531, 2972, 3385, 3662, 3806, 3898, 3969, 4001, 3981, 3901, 3718, 3405, 3004, 2589, 2162, 1664, 1061, 350, -471, -1395, -2406, -3485, -4613, -5792, -7003, -8261, -9583, -10933, -12265, -13577, -14862, -16131, -17387, -18625, -19862, -21062, -22183, -23228, -24198, -25086, -25900, -26632, -27274, -27823, -28270, -28628, -28915, -29130, -29263, -29311, -29269, -29127, -28889, -28570, -28187, -27743, -27246, -26705, -26152, -25619, -25090, -24514, -23894, -23252, -22608, -21983, -21378, -20807, -20291, -19847, -19466, -19110, -18758, -18445, -18208, -18040, -17902, -17779, -17704, -17724, -17831, -17984, -18159, -18361, -18593, -18850, -19122, -19399, -19680, -19969, -20257, -20529, -20771, -20982, -21165, -21313, -21416, -21460, -21436, -21326, -21123, -20838, -20485, -20059, -19533, -18907, -18193, -17404, -16548, -15611, -14593, -13502, -12336, -11101, -9835, -8541, -7211, -5827, -4403, -3015, -1709, -380};