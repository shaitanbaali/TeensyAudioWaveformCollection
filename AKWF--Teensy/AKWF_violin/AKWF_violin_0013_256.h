/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_violin_0013 256 samples */
 
const int16_t AKWF_violin_0013_256_DATA [256] = 
{1087, 4473, 7564, 10337, 12831, 15108, 17268, 19399, 21515, 23561, 25482, 27218, 28735, 29994, 31011, 31796, 32369, 32720, 32770, 32774, 32689, 32258, 31610, 30743, 29672, 28408, 26956, 25339, 23571, 21644, 19615, 17511, 15378, 13226, 11078, 8944, 6851, 4817, 2849, 961, -824, -2491, -4018, -5391, -6618, -7680, -8573, -9290, -9823, -10175, -10365, -10406, -10321, -10118, -9804, -9375, -8840, -8200, -7460, -6634, -5726, -4725, -3644, -2488, -1264, 0, 1308, 2649, 4004, 5367, 6705, 7964, 9128, 10159, 11052, 11816, 12456, 12985, 13410, 13725, 13929, 14027, 14023, 13920, 13724, 13446, 13100, 12694, 12240, 11734, 11195, 10650, 10121, 9617, 9145, 8676, 8170, 7595, 6922, 6162, 5319, 4389, 3375, 2289, 1118, -106, -1347, -2577, -3763, -4898, -5976, -6977, -7885, -8694, -9390, -9956, -10360, -10573, -10578, -10376, -9975, -9388, -8631, -7720, -6656, -5463, -4159, -2775, -1332, 150, 1661, 3202, 4765, 6340, 7910, 9443, 10941, 12374, 13721, 14979, 16113, 17094, 17893, 18480, 18849, 19001, 18931, 18640, 18130, 17403, 16469, 15359, 14093, 12693, 11168, 9537, 7818, 6037, 4196, 2321, 424, -1464, -3321, -5133, -6890, -8575, -10173, -11663, -13031, -14280, -15396, -16382, -17235, -17952, -18538, -18996, -19316, -19502, -19552, -19471, -19275, -18992, -18650, -18278, -17878, -17457, -17028, -16602, -16188, -15797, -15422, -15049, -14661, -14245, -13804, -13342, -12860, -12362, -11851, -11328, -10802, -10281, -9781, -9314, -8887, -8503, -8159, -7852, -7582, -7350, -7163, -7036, -6981, -7010, -7126, -7324, -7597, -7935, -8334, -8787, -9292, -9839, -10409, -10998, -11599, -12204, -12813, -13422, -14026, -14624, -15206, -15766, -16303, -16805, -17270, -17692, -18055, -18346, -18551, -18669, -18688, -18602, -18400, -18078, -17610, -16992, -16254, -15421, -14519, -13596, -12605, -11412, -9861, -7820, -5246, -2118};