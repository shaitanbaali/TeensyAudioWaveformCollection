/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_violin_0012 256 samples */
 
const int16_t AKWF_violin_0012_256_DATA [256] = 
{719, 2108, 3385, 4665, 5957, 7248, 8529, 9786, 11026, 12215, 13354, 14482, 15607, 16729, 17829, 18891, 19919, 20934, 21924, 22889, 23806, 24671, 25478, 26243, 26960, 27637, 28281, 28887, 29445, 29961, 30416, 30794, 31086, 31302, 31471, 31594, 31650, 31623, 31508, 31315, 31041, 30693, 30283, 29820, 29299, 28695, 27997, 27209, 26343, 25396, 24377, 23278, 22105, 20875, 19605, 18297, 16935, 15506, 14017, 12483, 10907, 9310, 7704, 6108, 4514, 2919, 1328, -263, -1854, -3441, -5018, -6576, -8105, -9610, -11069, -12490, -13871, -15217, -16530, -17787, -18983, -20133, -21236, -22304, -23331, -24309, -25237, -26114, -26940, -27714, -28432, -29085, -29685, -30246, -30778, -31258, -31657, -31975, -32231, -32447, -32626, -32748, -32769, -32767, -32760, -32664, -32499, -32277, -31996, -31661, -31283, -30859, -30370, -29784, -29105, -28376, -27612, -26814, -25965, -25049, -24078, -23059, -21979, -20853, -19676, -18456, -17189, -15888, -14555, -13196, -11820, -10423, -8994, -7533, -6050, -4571, -3113, -1663, -241, 1155, 2531, 3884, 5221, 6543, 7828, 9082, 10291, 11433, 12529, 13574, 14567, 15509, 16393, 17216, 17987, 18699, 19353, 19954, 20501, 21001, 21446, 21830, 22157, 22434, 22663, 22849, 22990, 23091, 23151, 23166, 23138, 23069, 22962, 22813, 22634, 22434, 22205, 21912, 21527, 21076, 20611, 20166, 19712, 19200, 18616, 17974, 17272, 16519, 15725, 14905, 14066, 13175, 12212, 11191, 10125, 9022, 7896, 6737, 5559, 4360, 3125, 1864, 565, -790, -2190, -3595, -4984, -6345, -7706, -9068, -10425, -11775, -13116, -14431, -15691, -16882, -18014, -19109, -20159, -21131, -21981, -22713, -23363, -23957, -24479, -24892, -25173, -25339, -25418, -25422, -25331, -25126, -24805, -24381, -23866, -23261, -22584, -21853, -21059, -20185, -19209, -18155, -17070, -15973, -14855, -13707, -12522, -11313, -10092, -8859, -7621, -6380, -5127, -3784, -2307, -729};