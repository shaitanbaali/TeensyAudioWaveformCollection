/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_violin_0001 256 samples */
 
const int16_t AKWF_violin_0001_256_DATA [256] = 
{299, 613, 537, 276, 379, 1008, 3201, 6974, 10950, 15250, 20013, 24588, 28546, 31514, 32767, 32189, 29990, 26926, 23050, 18775, 14837, 11502, 8775, 7036, 6746, 7814, 10044, 13137, 16336, 19181, 21907, 24134, 25075, 25282, 25288, 25334, 25387, 25768, 26293, 26266, 25571, 24055, 21728, 18721, 15317, 11551, 7456, 3476, -443, -4809, -9143, -13280, -16381, -18235, -19237, -19755, -19818, -19423, -18968, -18646, -18395, -17956, -17713, -17820, -18283, -19059, -20047, -21436, -22991, -24574, -25941, -26783, -27050, -26847, -26030, -24493, -22348, -19472, -16289, -13177, -10200, -7384, -4819, -2735, -1445, -955, -993, -1278, -1791, -2451, -3263, -4204, -5332, -6705, -7939, -9047, -10068, -10828, -10674, -9539, -7502, -4689, -1777, 1459, 4686, 7627, 10207, 12250, 13624, 14386, 14691, 14730, 14542, 14119, 13493, 12868, 12042, 10866, 9671, 8532, 7402, 6715, 6182, 5990, 6050, 6116, 5994, 5756, 5509, 4996, 4585, 4258, 3966, 3824, 3807, 3996, 4545, 5376, 6412, 7462, 8517, 9371, 9789, 9526, 8571, 7029, 4955, 2813, 957, -677, -1793, -1894, -1165, 110, 1761, 3399, 5018, 6327, 7131, 7280, 7033, 6614, 6077, 5549, 5213, 5258, 5175, 5040, 4777, 4207, 3394, 2308, 994, -239, -1355, -2157, -2402, -2114, -1487, -758, -31, 552, 662, 419, -55, -781, -1568, -2389, -3192, -3774, -4140, -4247, -3952, -3605, -3272, -2702, -2102, -1721, -1393, -1085, -888, -641, -304, -129, -237, -241, -166, -312, -449, -771, -1393, -2107, -2850, -4016, -5333, -6231, -6611, -6528, -6388, -6152, -5857, -5792, -5983, -6289, -6883, -8029, -9690, -11757, -14129, -16599, -18694, -20392, -21807, -22496, -22030, -20563, -18380, -15634, -13060, -10489, -8382, -7380, -7191, -7806, -9392, -11299, -12776, -13867, -14228, -13167, -11121, -8782, -6142, -3920, -2066, -451};