/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_violin_0005 256 samples */
 
const int16_t AKWF_violin_0005_256_DATA [256] = 
{1223, 3404, 5307, 7232, 9240, 11398, 13799, 16394, 19027, 21520, 23954, 26371, 28442, 29945, 31080, 31987, 32562, 32772, 32696, 32356, 31755, 30991, 29993, 28839, 27746, 26842, 26100, 25600, 25349, 25175, 24987, 24663, 24058, 22991, 21261, 19112, 16898, 14687, 12297, 9830, 7512, 5432, 3551, 1714, -15, -1494, -2755, -3798, -4621, -5040, -4805, -4214, -3540, -2821, -2007, -1237, -710, -524, -642, -1066, -1813, -2844, -4080, -5496, -7067, -8715, -10269, -11548, -12556, -13628, -14843, -15928, -17347, -18993, -20541, -21950, -23109, -23964, -24396, -24333, -23982, -23458, -22865, -22347, -21975, -21647, -21580, -21902, -22191, -22606, -23039, -23305, -23532, -23799, -24117, -24380, -24450, -24354, -24028, -23195, -21623, -19517, -17118, -14565, -11818, -8945, -6219, -3945, -2051, -49, 1611, 3000, 4465, 5879, 7094, 8093, 8826, 9140, 9187, 9141, 9184, 9472, 10031, 10831, 11959, 13496, 15176, 16879, 18700, 20547, 21992, 23313, 24487, 25376, 26102, 26610, 26906, 26950, 26720, 26512, 26346, 26182, 26065, 25938, 25887, 25758, 25400, 25157, 24836, 24275, 23491, 22501, 21596, 20847, 20234, 19847, 19718, 19695, 19623, 19505, 19412, 19191, 18715, 18020, 17094, 16001, 14794, 13519, 12198, 10790, 9316, 7793, 6171, 4551, 2899, 1204, -442, -1941, -3404, -4910, -6317, -7660, -9009, -10322, -11532, -12899, -14262, -15525, -16807, -18081, -19379, -20757, -22152, -23359, -24393, -25362, -26200, -26611, -26675, -26479, -26094, -25629, -25172, -24659, -24164, -23873, -23638, -23423, -23157, -22744, -22256, -21604, -20806, -19918, -18830, -17751, -16690, -15582, -14658, -14084, -13647, -13286, -13226, -13063, -12810, -12563, -12266, -12135, -11921, -11674, -11622, -11298, -11094, -11035, -10793, -10491, -9872, -8940, -7874, -6697, -5658, -4835, -4247, -4021, -4350, -4847, -5352, -6116, -6743, -7096, -6929, -6091, -5182, -4050, -2643, -940};