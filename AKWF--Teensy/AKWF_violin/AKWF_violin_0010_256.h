/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_violin_0010 256 samples */
 
const int16_t AKWF_violin_0010_256_DATA [256] = 
{80, 462, 1496, 3073, 4709, 6234, 7709, 9148, 10516, 11796, 12973, 14054, 15067, 15994, 16828, 17554, 18152, 18595, 18891, 19071, 19164, 19161, 19066, 18878, 18603, 18247, 17827, 17376, 16908, 16396, 15832, 15246, 14694, 14200, 13733, 13277, 12836, 12394, 11952, 11575, 11318, 11165, 11038, 10909, 10814, 10783, 10819, 10922, 11097, 11333, 11615, 11944, 12328, 12770, 13276, 13852, 14496, 15199, 15950, 16745, 17579, 18462, 19377, 20322, 21303, 22324, 23391, 24455, 25475, 26447, 27367, 28222, 29049, 29865, 30640, 31320, 31874, 32297, 32578, 32723, 32769, 32735, 32587, 32291, 31844, 31239, 30467, 29570, 28594, 27541, 26370, 25071, 23679, 22267, 20829, 19321, 17711, 16056, 14431, 12853, 11312, 9815, 8358, 6931, 5542, 4187, 2888, 1654, 526, -486, -1409, -2256, -3007, -3623, -4087, -4428, -4672, -4823, -4895, -4901, -4830, -4666, -4417, -4103, -3740, -3321, -2832, -2289, -1757, -1279, -827, -353, 140, 623, 1080, 1500, 1863, 2168, 2440, 2705, 2925, 3028, 2995, 2874, 2697, 2462, 2163, 1803, 1361, 813, 172, -534, -1288, -2122, -3086, -4153, -5269, -6410, -7582, -8824, -10124, -11438, -12740, -14052, -15397, -16764, -18116, -19428, -20684, -21884, -23010, -24108, -25199, -26238, -27161, -27956, -28653, -29287, -29838, -30264, -30566, -30755, -30844, -30839, -30750, -30584, -30330, -29977, -29533, -29004, -28408, -27744, -27018, -26250, -25471, -24701, -23921, -23075, -22185, -21331, -20556, -19837, -19134, -18446, -17787, -17162, -16596, -16135, -15780, -15492, -15243, -15037, -14877, -14763, -14717, -14757, -14873, -15048, -15273, -15523, -15774, -16026, -16287, -16561, -16841, -17121, -17398, -17668, -17924, -18146, -18306, -18397, -18426, -18392, -18309, -18199, -18054, -17824, -17477, -17046, -16571, -16047, -15436, -14713, -13885, -12963, -11947, -10854, -9702, -8486, -7207, -5875, -4449, -2844, -1272, -261};