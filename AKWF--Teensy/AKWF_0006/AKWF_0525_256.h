/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0525 256 samples */
 
const int16_t AKWF_0525_256_DATA [256] = 
{-67, 382, 857, 3277, 5144, 5538, 6648, 9766, 9663, 9637, 10400, 11175, 14320, 14911, 15665, 15547, 15675, 18905, 19691, 20451, 20415, 20452, 20303, 20918, 24179, 24186, 24177, 24164, 24233, 25190, 25281, 25256, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25269, 25242, 25310, 28597, 29121, 28991, 29015, 29015, 29015, 28954, 29287, 27574, 24978, 25326, 25261, 25261, 25242, 25347, 24653, 24096, 24198, 24179, 24179, 24134, 24388, 21429, 20210, 20472, 20425, 20425, 20425, 20425, 20425, 20405, 20511, 19892, 19257, 19363, 19343, 19343, 19285, 19602, 16831, 15327, 15705, 15313, 14447, 14505, 14583, 11444, 10434, 9691, 9624, 9888, 6986, 5623, 4937, 4754, 5127, 2572, 804, 1143, 1061, 1166, 562, -109, 117, -383, -3679, -3778, -3743, -3752, -3752, -3752, -3752, -3752, -3752, -3752, -3752, -3752, -3752, -3752, -3752, -3752, -3702, -3982, -2722, 522, -2262, -4033, -3689, -3752, -3752, -3752, -3752, -3752, -3752, -3752, -3770, -3674, -4449, -4911, -4819, -4904, -4536, -6790, -8893, -8485, -8731, -9671, -9727, -9428, -12280, -13675, -13308, -13727, -14576, -14498, -14463, -17690, -18418, -18146, -18750, -19430, -19324, -19399, -19094, -20585, -23355, -23039, -23108, -23043, -23334, -24224, -24170, -24179, -24179, -24241, -23908, -25620, -28216, -27868, -27946, -27870, -28222, -29076, -29002, -29047, -28870, -29626, -32832, -32758, -32764, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32743, -32873, -32349, -29064, -28997, -29024, -29015, -29015, -29015, -29015, -29015, -29015, -29015, -29015, -29015, -29015, -29002, -29079, -28235, -27868, -27947, -27932, -27932, -27932, -27932, -27932, -27864, -28229, -26134, -23874, -24277, -24069, -23118, -23029, -23362, -20643, -19016, -18619, -17303, -14414, -13949, -13435, -10422, -9292, -8898, -7031, -4612, -4136, -3686};