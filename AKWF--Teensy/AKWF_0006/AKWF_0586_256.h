/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0586 256 samples */
 
const int16_t AKWF_0586_256_DATA [256] = 
{933, 2921, 4894, 6899, 8930, 10991, 13071, 15153, 17223, 19234, 21120, 22847, 24384, 25724, 26868, 27822, 28606, 29252, 29788, 30247, 30649, 31000, 31288, 31505, 31642, 31680, 31566, 31273, 30802, 30171, 29392, 28481, 27457, 26351, 25185, 23979, 22747, 21486, 20174, 18780, 17246, 15545, 13694, 11714, 9640, 7525, 5395, 3297, 1278, -648, -2458, -4142, -5715, -7181, -8551, -9842, -11060, -12207, -13280, -14264, -15151, -15946, -16645, -17253, -17781, -18242, -18661, -19063, -19464, -19879, -20302, -20728, -21140, -21482, -21697, -21752, -21635, -21365, -20955, -20433, -19837, -19206, -18579, -17996, -17470, -17011, -16603, -16232, -15891, -15560, -15191, -14762, -14280, -13759, -13210, -12649, -12087, -11544, -11029, -10552, -10109, -9690, -9276, -8853, -8411, -7944, -7453, -6870, -6497, -3691, 1739, 6452, 9772, 10836, 9106, 4504, -2571, -11176, -19956, -27386, -31961, -32563, -28691, -20678, -9390, -4257, -2965, -965, 962, 2915, 4893, 6901, 8932, 10992, 13073, 15154, 17226, 19236, 21122, 22849, 24387, 25726, 26870, 27825, 28609, 29254, 29790, 30249, 30652, 31003, 31291, 31506, 31645, 31681, 31567, 31275, 30804, 30174, 29394, 28483, 27459, 26353, 25187, 23980, 22749, 21488, 20176, 18782, 17248, 15546, 13695, 11716, 9643, 7526, 5396, 3300, 1279, -646, -2455, -4140, -5713, -7179, -8549, -9840, -11057, -12204, -13278, -14261, -15148, -15945, -16643, -17251, -17779, -18241, -18659, -19060, -19462, -19878, -20301, -20727, -21138, -21480, -21695, -21751, -21634, -21363, -20953, -20431, -19835, -19204, -18577, -17994, -17469, -17009, -16601, -16230, -15890, -15558, -15188, -14760, -14277, -13756, -13209, -12647, -12085, -11542, -11028, -10550, -10108, -9688, -9273, -8852, -8409, -7943, -7451, -6867, -6496, -3689, 1740, 6454, 9774, 10838, 9108, 4505, -2569, -11174, -19954, -27384, -31958, -32561, -28690, -20677, -9390, -4210, -2850, -750};