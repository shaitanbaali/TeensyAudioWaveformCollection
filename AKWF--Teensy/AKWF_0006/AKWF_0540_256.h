/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0540 256 samples */
 
const int16_t AKWF_0540_256_DATA [256] = 
{4397, 18544, 28276, 32545, 31559, 26424, 18680, 9937, 1524, -5564, -10750, -13921, -15247, -15113, -13983, -12284, -10361, -8418, -6555, -4792, -3091, -1444, 129, 1591, 2872, 3892, 4557, 4767, 4465, 3671, 2498, 1115, -287, -1508, -2391, -2827, -2760, -2215, -1273, -77, 1213, 2429, 3426, 4114, 4443, 4413, 4067, 3474, 2724, 1894, 1060, 285, -397, -961, -1405, -1740, -1916, -2281, -2943, -5564, -9273, -10577, -8884, -4916, 127, 4963, 8597, 10458, 10427, 8777, 6035, 2840, -221, -2695, -4324, -5070, -5042, -4453, -3546, -2548, -1628, -875, -317, 76, 378, 667, 1024, 1496, 2076, 2707, 3298, 3747, 3967, 3867, 3371, 2442, 1105, -519, -2259, -3919, -5299, -6244, -6642, -6444, -5674, -4424, -2841, -1096, 623, 2152, 3374, 4218, 4665, 4743, 4511, 4048, 3432, 2741, 2040, 1363, 791, 181, -1490, -1057, -12979, -25226, -22670, -21652, -12487, 1904, 15329, 24891, 29419, 29174, 25201, 18884, 11571, 4425, -1685, -6306, -9286, -10752, -11022, -10463, -9442, -8245, -7082, -6074, -5259, -4633, -4144, -3711, -3262, -2733, -2089, -1323, -457, 463, 1377, 2225, 2955, 3527, 3921, 4128, 4159, 4034, 3780, 3427, 2999, 2518, 2005, 1477, 952, 448, -18, -431, -772, -1020, -1155, -1153, -995, -670, -201, 357, 922, 1404, 1719, 1792, 1547, 931, -59, -1350, -2802, -4224, -5436, -6274, -6617, -6400, -5623, -4362, -2739, -923, 895, 2556, 3920, 4899, 5459, 5615, 5419, 4945, 4282, 3512, 2703, 1916, 1189, 542, -13, -478, -863, -1168, -1403, -1575, -1687, -1739, -1735, -1677, -1569, -1423, -1262, -1119, -1024, -1001, -1056, -1168, -1301, -1409, -1449, -1389, -1208, -912, -525, -77, 388, 828, 1211, 1514, 1720, 1810, 1939, 1200, 3311, -7213, -23727, -21379, -19016, -9981};