/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0553 256 samples */
 
const int16_t AKWF_0553_256_DATA [256] = 
{847, 2194, 3496, 4788, 6076, 7382, 8723, 10098, 11515, 12965, 14427, 15895, 17355, 18800, 20237, 21672, 23111, 24568, 26045, 27535, 29041, 30533, 32103, 32712, 31891, 30834, 30041, 29096, 28096, 27036, 25838, 24665, 23466, 22352, 21323, 20368, 19484, 18602, 17696, 16731, 15692, 14589, 13448, 12299, 11169, 10080, 9026, 7994, 6965, 5905, 4799, 3639, 2423, 1170, -101, -1374, -2634, -3876, -5113, -6351, -7606, -8896, -10222, -11585, -12980, -14387, -15797, -17205, -18597, -19983, -21366, -22754, -24155, -25578, -27015, -28467, -29916, -31408, -32653, -32401, -31381, -30470, -29693, -28707, -27748, -26653, -25491, -24342, -23184, -22123, -21130, -20215, -19355, -18490, -17602, -16650, -15629, -14549, -13428, -12301, -11195, -10123, -9087, -8075, -7062, -6024, -4944, -3808, -2534, -1643, 1025, 14793, 23978, 30730, 31358, 27653, 24104, 20937, 18479, 15954, 13150, 10445, 8015, 5664, 3159, 506, -2119, -4630, -7087, -9586, -12174, -14802, -17382, -19892, -22358, -24815, -27291, -29778, -32240, -32209, -30551, -29183, -27594, -25812, -23978, -22251, -20739, -19394, -18077, -16669, -15122, -13471, -11818, -10237, -8737, -7281, -5800, -4230, -2563, -831, 919, 2642, 4330, 6002, 7688, 9424, 11221, 13062, 14922, 16775, 18598, 20401, 22197, 23999, 25827, 27676, 29511, 31448, 32711, 31896, 30644, 29645, 28444, 27191, 25765, 24342, 22934, 21662, 20504, 19443, 18397, 17307, 16120, 14845, 13508, 12160, 10850, 9594, 8382, 7188, 5967, 4684, 3332, 1916, 459, -1000, -2448, -3873, -5279, -6694, -8135, -9615, -11145, -12713, -14299, -15890, -17469, -19030, -20583, -22132, -23690, -25269, -26868, -28479, -30080, -31773, -32731, -31982, -30847, -29991, -28968, -27904, -26729, -25455, -24198, -22948, -21813, -20761, -19799, -18868, -17920, -16913, -15824, -14668, -13461, -12249, -11064, -9918, -8815, -7733, -6642, -5516, -4335, -3091, -1800, -450};