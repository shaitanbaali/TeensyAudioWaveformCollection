/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0569 256 samples */
 
const int16_t AKWF_0569_256_DATA [256] = 
{3200, 7141, 9536, 11398, 12911, 14192, 15308, 16294, 17182, 17991, 18731, 19416, 20053, 20647, 21205, 21732, 22228, 22699, 23146, 23570, 23976, 24364, 24734, 25088, 25428, 25754, 26069, 26369, 26659, 26939, 27208, 27466, 27716, 27958, 28189, 28414, 28630, 28838, 29040, 29234, 29421, 29602, 29777, 29945, 30109, 30264, 30414, 30560, 30699, 30834, 30963, 31088, 31207, 31321, 31430, 31535, 31634, 31729, 31820, 31907, 31988, 32067, 32140, 32209, 32275, 32335, 32391, 32444, 32493, 32537, 32578, 32615, 32647, 32676, 32700, 32722, 32739, 32753, 32316, 34691, 22873, -1273, -2811, -5417, -7153, -8549, -9724, -10746, -11650, -12462, -13201, -13878, -14504, -15086, -15631, -16142, -16625, -17081, -17514, -17927, -18319, -18694, -19054, -19398, -19730, -20050, -20357, -20653, -20939, -21215, -21483, -21742, -21993, -22237, -22474, -22703, -22925, -23143, -23353, -23559, -23759, -23954, -24144, -24329, -24509, -24686, -24858, -25025, -25189, -25349, -25506, -25659, -25809, -25955, -26099, -26238, -26375, -26509, -26640, -26769, -26895, -27017, -27138, -27256, -27372, -27485, -27596, -27706, -27812, -27916, -28019, -28118, -28217, -28314, -28408, -28501, -28591, -28681, -28768, -28853, -28938, -29020, -29101, -29181, -29258, -29334, -29409, -29482, -29554, -29625, -29693, -29761, -29827, -29893, -29957, -30019, -30080, -30142, -30200, -30258, -30316, -30371, -30425, -30479, -30532, -30583, -30634, -30683, -30731, -30780, -30827, -30872, -30916, -30961, -31004, -31047, -31088, -31129, -31169, -31207, -31246, -31284, -31320, -31357, -31392, -31427, -31461, -31494, -31528, -31559, -31594, -31633, -31670, -31706, -31741, -31776, -31810, -31843, -31874, -31905, -31936, -31964, -31993, -32020, -32047, -32072, -32097, -32121, -32144, -32166, -32188, -32208, -32228, -32247, -32264, -32281, -32297, -32313, -32327, -32340, -32352, -32365, -32376, -32386, -32396, -32404, -32411, -32419, -32425, -32430, -32434, -32438, -32441, -31911, -34774, -19426};