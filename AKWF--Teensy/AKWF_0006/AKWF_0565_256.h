/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0565 256 samples */
 
const int16_t AKWF_0565_256_DATA [256] = 
{1982, 5749, 8349, 10457, 12228, 13760, 15118, 16333, 17437, 18449, 19380, 20245, 21050, 21800, 22507, 23170, 23793, 24383, 24940, 25466, 25964, 26436, 26883, 27307, 27708, 28088, 28448, 28788, 29108, 29413, 29698, 29967, 30219, 30456, 30677, 30882, 31074, 31249, 31412, 31559, 31693, 31813, 31919, 32013, 32093, 32159, 32213, 32254, 32287, 32269, 32536, 32592, 33490, 25943, 19535, 18603, 17322, 16401, 15631, 14971, 14389, 13867, 13394, 12962, 12563, 12194, 11851, 11529, 11228, 10945, 10677, 10426, 10187, 9961, 9747, 9545, 9353, 9170, 8996, 8832, 8676, 8528, 8388, 8255, 8129, 8011, 7899, 7794, 7695, 7603, 7516, 7435, 7360, 7291, 7229, 7170, 7118, 7071, 7029, 6994, 6961, 6936, 6915, 6900, 6827, 7150, 5566, 1634, 1044, 461, 40, -303, -593, -845, -1067, -1264, -1443, -1604, -1750, -1884, -2005, -2116, -2217, -2309, -2392, -2468, -2536, -2596, -2650, -2697, -2738, -2772, -2801, -2822, -2839, -2907, -2607, -4821, -7017, -7312, -7727, -8023, -8270, -8483, -8669, -8838, -8990, -9131, -9261, -9382, -9495, -9601, -9701, -9796, -9886, -9972, -10054, -10133, -10207, -10280, -10349, -10414, -10478, -10540, -10599, -10656, -10710, -10764, -10815, -10864, -10913, -10959, -11004, -11047, -11089, -11130, -11169, -11207, -11243, -11279, -11314, -11346, -11378, -11410, -11439, -11469, -11496, -11523, -11550, -11575, -11599, -11622, -11645, -11666, -11688, -11707, -11726, -11744, -11762, -11778, -11793, -11808, -11823, -11836, -11849, -11860, -11871, -11882, -11891, -11900, -11908, -11916, -11922, -11928, -11933, -11937, -11941, -11945, -11946, -11917, -12084, -11011, -9766, -9625, -9432, -9318, -9372, -8657, -15891, -20997, -21841, -22934, -23724, -24375, -24925, -25402, -25819, -26186, -26510, -26796, -27049, -27271, -27467, -27635, -27780, -27901, -27999, -28076, -28134, -28155, -28218, -28670, -28750, -28658, -29487, -7840};