/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0579 256 samples */
 
const int16_t AKWF_0579_256_DATA [256] = 
{356, 1264, 2153, 3044, 3934, 4825, 5717, 6606, 7496, 8388, 9276, 10164, 11054, 11940, 12829, 13717, 14603, 15489, 16376, 17261, 18147, 19031, 19914, 20799, 21683, 22564, 23448, 24330, 25211, 26094, 26973, 27853, 28734, 29613, 30489, 31353, 32305, 32143, 31144, 30262, 29358, 28452, 27550, 26645, 25740, 24837, 23932, 23027, 22125, 21221, 20316, 19415, 18511, 17607, 16707, 15803, 14901, 14001, 13099, 12198, 11300, 10398, 9499, 8601, 7701, 6803, 5906, 5007, 4084, 3372, 1629, -988, -787, -2744, -3974, -4731, -5542, -6341, -7142, -7941, -8738, -9537, -10336, -11131, -11928, -12724, -13519, -14316, -15110, -15904, -16698, -17491, -18284, -19078, -19869, -20660, -21452, -22241, -23031, -23823, -24611, -25399, -26189, -26976, -27764, -28548, -29335, -30126, -29742, -28860, -28066, -27255, -26445, -25258, -26490, -15313, 2010, 662, 1843, 2631, 3418, 4202, 4988, 5497, 7761, -1252, -7726, -4669, -3365, -1786, -208, 1374, 2950, 4528, 6108, 7683, 9261, 10839, 12413, 13988, 15565, 17136, 18709, 20278, 21874, 22943, 23675, 24454, 25227, 25998, 26758, 27557, 28195, 27600, 26771, 25992, 25203, 24413, 23624, 22835, 22044, 21254, 20464, 19674, 18886, 18096, 17305, 16517, 15728, 14938, 14152, 13170, 13433, 7436, -2603, -2382, -3318, -4926, 425, 2446, 56, -1452, -3095, -4744, -6389, -8031, -9676, -11316, -12963, -14586, -15607, -16438, -17309, -18169, -19028, -19889, -20748, -21606, -22464, -23321, -24178, -25035, -25890, -26744, -27601, -28453, -29308, -30161, -31004, -31885, -32614, -31980, -31054, -30189, -29313, -28433, -27555, -26679, -25800, -24922, -24045, -23166, -22289, -21412, -20533, -19657, -18781, -17904, -17028, -16152, -15275, -14402, -13526, -12651, -11778, -10903, -10029, -9158, -8284, -7411, -6541, -5669, -4797, -3929, -3057, -2189, -1317, -462, -262, -294, -281, -278, -275, -272, -270, -267};