/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0555 256 samples */
 
const int16_t AKWF_0555_256_DATA [256] = 
{210, 688, 1155, 1620, 2081, 2540, 2996, 3447, 3896, 4341, 4780, 5217, 5649, 6076, 6497, 6913, 7321, 7725, 8122, 8511, 8895, 9271, 9640, 10003, 10359, 10709, 11053, 11390, 11721, 12044, 12363, 12675, 12981, 13280, 13573, 13860, 14142, 14416, 14686, 14951, 15210, 15466, 15715, 15962, 16204, 16442, 16678, 16910, 17139, 17366, 17590, 17811, 18031, 18250, 18465, 18680, 18893, 19107, 19320, 19533, 19745, 19959, 20173, 20388, 20604, 20821, 21041, 21262, 21484, 21709, 21937, 22165, 22397, 22632, 22869, 23109, 23354, 23600, 23850, 24105, 24363, 24625, 24890, 25159, 25432, 25709, 25988, 26272, 26560, 26852, 27148, 27446, 27750, 28057, 28368, 28681, 29000, 29321, 29645, 29973, 30305, 30639, 30977, 31316, 31659, 32003, 32352, 32668, 32768, 32575, 32085, 31329, 30375, 29233, 27895, 26390, 24735, 22943, 21017, 18970, 16833, 14622, 12345, 10040, 7729, 5425, 3153, 932, -1233, -3323, -5341, -7288, -9154, -10948, -12674, -14326, -15914, -17433, -18878, -20250, -21542, -22745, -23860, -24883, -25804, -26631, -27363, -28000, -28552, -29025, -29423, -29759, -30035, -30258, -30434, -30565, -30652, -30697, -30700, -30661, -30580, -30458, -30295, -30096, -29864, -29602, -29315, -29011, -28693, -28365, -28035, -27702, -27368, -27037, -26706, -26376, -26047, -25718, -25387, -25055, -24722, -24389, -24059, -23730, -23407, -23093, -22786, -22491, -22207, -21934, -21671, -21418, -21173, -20935, -20701, -20470, -20242, -20014, -19787, -19560, -19334, -19109, -18886, -18664, -18444, -18228, -18011, -17794, -17578, -17361, -17139, -16913, -16683, -16444, -16199, -15947, -15685, -15417, -15141, -14857, -14566, -14269, -13966, -13656, -13340, -13017, -12686, -12346, -12001, -11645, -11279, -10906, -10523, -10131, -9732, -9325, -8909, -8489, -8062, -7631, -7195, -6754, -6309, -5861, -5409, -4952, -4494, -4029, -3564, -3096, -2623, -2150, -1677, -1202, -729, -248};