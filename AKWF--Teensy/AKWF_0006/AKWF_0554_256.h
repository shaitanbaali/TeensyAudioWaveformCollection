/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0554 256 samples */
 
const int16_t AKWF_0554_256_DATA [256] = 
{509, 2037, 3531, 5029, 6524, 8022, 9523, 11023, 12528, 14039, 15548, 17063, 18586, 20108, 21628, 23133, 24601, 26018, 27355, 28587, 29695, 30655, 31446, 32060, 32485, 32718, 32763, 32627, 32317, 31848, 31232, 30487, 29623, 28661, 27608, 26477, 25281, 24027, 22725, 21387, 20014, 18619, 17206, 15776, 14336, 12893, 11441, 9987, 8535, 7080, 5625, 4177, 2728, 1282, -155, -1596, -3033, -4467, -5905, -7342, -8779, -10223, -11667, -13115, -14571, -16027, -17489, -18958, -20427, -21893, -23343, -24758, -26121, -27411, -28600, -29674, -30610, -31388, -32000, -32437, -32693, -32770, -32673, -32410, -31992, -31432, -30745, -29941, -29035, -28042, -26966, -25823, -24623, -23369, -22078, -20750, -19394, -18019, -16625, -15218, -13804, -12382, -10953, -9526, -8095, -6663, -5234, -3805, -2166, -1799, 6845, 21062, 27766, 31760, 32764, 31689, 29381, 26414, 23132, 19722, 16316, 12973, 9707, 6540, 3471, 486, -2410, -5239, -8017, -10744, -13435, -16098, -18728, -21328, -23857, -26225, -28344, -30117, -31463, -32342, -32741, -32680, -32200, -31359, -30219, -28835, -27258, -25534, -23693, -21770, -19796, -17780, -15747, -13710, -11669, -9637, -7618, -5607, -3615, -1642, 319, 2260, 4191, 6116, 8027, 9936, 11844, 13746, 15649, 17553, 19452, 21348, 23217, 25023, 26732, 28298, 29673, 30828, 31726, 32350, 32695, 32761, 32565, 32121, 31461, 30609, 29588, 28430, 27152, 25773, 24317, 22794, 21218, 19607, 17968, 16307, 14639, 12962, 11280, 9602, 7923, 6247, 4583, 2922, 1267, -375, -2015, -3651, -5279, -6910, -8538, -10164, -11795, -13427, -15059, -16697, -18339, -19979, -21619, -23236, -24810, -26320, -27728, -29007, -30133, -31078, -31821, -32355, -32670, -32769, -32660, -32352, -31862, -31207, -30408, -29478, -28437, -27303, -26081, -24791, -23446, -22050, -20615, -19156, -17671, -16170, -14661, -13140, -11616, -10093, -8564, -7041, -5519, -4001, -2492, -955};