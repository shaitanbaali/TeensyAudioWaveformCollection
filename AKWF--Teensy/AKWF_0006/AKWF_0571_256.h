/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0571 256 samples */
 
const int16_t AKWF_0571_256_DATA [256] = 
{20117, 23128, 24616, 25738, 26611, 27328, 27935, 28456, 28914, 29318, 29675, 29995, 30281, 30536, 30763, 30966, 31145, 31302, 31438, 31554, 31652, 31730, 31790, 31841, 31797, 32155, 32146, 31391, 31377, 31292, 31238, 31193, 31156, 31124, 31095, 31069, 31047, 31024, 31004, 30987, 30969, 30952, 30938, 30923, 30909, 30896, 30883, 30871, 30860, 30851, 30839, 30829, 30819, 30810, 30802, 30793, 30784, 30775, 30768, 30761, 30753, 30747, 30739, 30733, 30727, 30721, 30715, 30709, 30704, 30698, 30692, 30686, 30681, 30677, 30671, 30668, 30662, 30658, 30654, 30650, 30645, 30642, 30638, 30635, 30631, 30627, 30624, 30620, 30617, 30615, 30611, 30609, 30606, 30603, 30600, 30597, 30595, 30592, 30591, 30588, 30586, 30584, 30582, 30580, 30579, 30578, 30575, 30574, 30573, 30571, 30569, 30569, 30567, 30567, 30564, 30565, 30563, 30562, 30562, 30563, 30560, 30559, 30559, 30559, 30559, 30559, 30268, 31813, 21472, 11467, 11344, 10136, 9390, 8783, 8269, 7822, 7427, 7071, 6748, 6449, 6175, 5921, 5681, 5458, 5247, 5047, 4857, 4678, 4506, 4343, 4186, 4037, 3891, 3754, 3620, 3492, 3368, 3250, 3134, 3023, 2916, 2812, 2710, 2613, 2519, 2427, 2337, 2251, 2168, 2086, 2007, 1929, 1855, 1783, 1713, 1643, 1578, 1512, 1450, 1389, 1330, 1272, 1216, 1162, 1109, 1058, 1007, 960, 914, 867, 823, 779, 739, 697, 659, 621, 585, 551, 516, 483, 452, 422, 393, 364, 337, 311, 287, 262, 240, 218, 197, 178, 159, 142, 126, 110, 96, 83, 70, 59, 49, 39, 31, 23, 17, 11, 7, 3, 1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0};