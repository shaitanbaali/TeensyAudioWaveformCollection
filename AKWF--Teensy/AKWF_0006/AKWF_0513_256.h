/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0513 256 samples */
 
const int16_t AKWF_0513_256_DATA [256] = 
{18865, 35254, 32199, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32667, 33183, 30753, 21166, 20768, 20897, 20856, 20856, 20856, 20856, 20856, 20856, 20856, 20856, 20856, 20856, 20856, 20856, 20856, 20856, 20856, 20856, 20856, 20856, 20856, 20856, 20856, 20856, 20856, 20856, 20856, 20856, 20856, 20856, 20856, 20856, 20856, 20856, 20856, 20856, 20856, 20856, 20856, 21017, 20127, 26295, 33453, 32616, 32766, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32632, 32701, 33446, -16976, -35776, -32064, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32667, -33183, -30753, -21166, -20769, -20897, -20856, -20856, -20856, -20856, -20856, -20856, -20856, -20856, -20856, -20856, -20856, -20856, -20856, -20856, -20856, -20856, -20856, -20856, -20856, -20856, -20856, -20856, -20856, -20856, -20856, -20856, -20856, -20856, -20856, -20856, -20856, -20856, -20856, -20856, -20856, -20856, -20856, -21018, -20127, -26295, -33453, -32616, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32767, -32766, -32767};