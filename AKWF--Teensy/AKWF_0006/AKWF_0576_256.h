/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0576 256 samples */
 
const int16_t AKWF_0576_256_DATA [256] = 
{463, 1352, 2222, 3095, 3966, 4839, 5712, 6583, 7455, 8326, 9195, 10067, 10937, 11805, 12675, 13545, 14411, 15280, 16148, 17013, 17881, 18748, 19612, 20478, 21343, 22207, 23071, 23934, 24797, 25661, 26522, 27383, 28245, 29106, 29966, 30823, 31680, 32557, 32176, 31209, 30343, 29457, 28572, 27686, 26800, 25915, 25029, 24142, 23258, 22373, 21487, 20603, 19717, 18833, 17950, 17065, 16181, 15300, 14416, 13533, 12651, 11768, 10888, 10007, 9125, 8246, 7367, 6486, 5608, 4729, 3850, 2973, 2096, 1218, 343, -533, -1409, -2283, -3157, -4026, -4928, -5251, -5207, -5217, -5219, -5220, -5220, -5219, -5218, -5217, -5216, -5216, -5215, -5212, -5211, -5210, -5209, -5206, -5205, -5203, -5201, -5199, -5196, -5194, -5192, -5190, -5187, -5185, -5183, -5180, -5177, -5176, -5172, -5170, -5168, -5165, -5162, -5159, -5157, -5155, -5152, -5149, -5147, -5143, -5142, -5139, -5136, -5133, -5131, -5128, -5125, -5122, -5121, -5118, -5115, -5112, -5109, -5106, -5103, -5102, -5099, -5096, -5093, -5090, -5087, -5084, -5082, -5080, -5077, -5075, -5072, -5069, -5066, -5063, -5060, -5059, -5056, -5053, -5050, -5047, -5044, -5041, -5039, -5037, -5034, -5031, -5032, -5029, -5015, -6152, -8339, -7564, -6531, -8508, -9988, -11547, -13100, -14658, -16215, -17768, -19325, -20535, -23929, -13942, -5015, -8028, -8911, -10127, -11342, -12560, -13776, -14991, -16209, -17423, -18638, -19855, -21068, -22248, -23526, -24745, -7617, -4311, -5218, -5158, -5244, -5333, -5420, -5508, -5597, -5685, -5775, -5863, -5952, -6042, -6131, -6221, -6311, -6400, -6490, -6580, -6670, -6760, -6850, -6940, -7030, -7120, -7211, -7300, -7391, -7481, -7571, -7661, -7751, -7841, -7932, -8021, -8112, -8201, -8291, -8304, -8796, -6486, -3894, -3910, -3536, -2844, -4168, -6296, -5490, -5098, -4640, -3899, -3008, -2138, -1267, -377};