/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0588 256 samples */
 
const int16_t AKWF_0588_256_DATA [256] = 
{2707, 7333, 11864, 16408, 20943, 25432, 30217, 32631, 32378, 32392, 32357, 32319, 32281, 32240, 32200, 32158, 32116, 32073, 32028, 31984, 31939, 31894, 31849, 31803, 31757, 31710, 31662, 31615, 31568, 31520, 31473, 31426, 31376, 31328, 31281, 31230, 31184, 31134, 31086, 31036, 30988, 30939, 30890, 30841, 30792, 30743, 30694, 30645, 30596, 30548, 30498, 30449, 30375, 30423, 29878, 27001, 23941, 20934, 17905, 14884, 11865, 8838, 5818, 2802, -221, -3236, -6253, -9273, -12283, -15295, -18312, -21319, -24328, -27310, -30440, -32734, -32752, -32722, -32712, -32692, -32671, -32648, -32626, -32602, -32579, -32555, -32529, -32504, -32478, -32453, -32426, -32399, -32372, -32346, -32317, -32288, -32261, -32233, -32204, -32177, -32147, -32120, -32091, -32062, -32033, -32004, -31976, -31946, -31917, -31888, -31858, -31830, -31801, -31771, -31742, -31712, -31682, -31653, -31623, -31546, -31734, -29281, -24484, -19985, -15438, -10879, -6330, -1786, 2769, 7312, 11856, 16408, 20945, 25432, 30217, 32631, 32378, 32392, 32358, 32319, 32281, 32240, 32200, 32159, 32116, 32073, 32028, 31985, 31940, 31895, 31849, 31803, 31757, 31710, 31662, 31615, 31568, 31520, 31473, 31426, 31376, 31328, 31281, 31231, 31184, 31134, 31086, 31038, 30988, 30939, 30891, 30842, 30793, 30743, 30695, 30645, 30597, 30548, 30498, 30449, 30375, 30423, 29879, 27002, 23942, 20934, 17905, 14884, 11865, 8838, 5819, 2802, -221, -3236, -6252, -9273, -12282, -15296, -18311, -21318, -24329, -27309, -30439, -32734, -32752, -32722, -32712, -32692, -32670, -32648, -32626, -32602, -32579, -32554, -32529, -32504, -32478, -32452, -32426, -32399, -32372, -32346, -32316, -32288, -32261, -32233, -32204, -32177, -32147, -32119, -32090, -32061, -32033, -32004, -31974, -31946, -31917, -31888, -31858, -31829, -31800, -31770, -31741, -31712, -31682, -31653, -31623, -31546, -31734, -29281, -24484, -19985, -15438, -10887, -6350, -1722};