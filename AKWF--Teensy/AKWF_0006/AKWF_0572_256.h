/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0572 256 samples */
 
const int16_t AKWF_0572_256_DATA [256] = 
{6634, 10508, 13102, 15271, 17135, 18783, 20268, 21606, 22830, 23951, 24976, 25915, 26776, 27558, 28271, 28914, 29488, 30000, 30446, 30830, 31153, 31415, 31616, 31768, 31798, 32080, 32659, 32434, 32334, 32249, 32177, 32113, 32056, 32004, 31954, 31908, 31864, 31824, 31784, 31747, 31712, 31677, 31646, 31613, 31582, 31552, 31524, 31497, 31470, 31444, 31416, 31403, 31411, 31398, 31381, 31361, 31339, 31316, 31292, 31269, 31246, 31221, 31196, 31173, 31150, 31126, 31104, 31082, 31061, 31041, 31020, 31001, 30981, 30964, 30948, 30932, 30917, 30903, 30889, 30876, 30865, 30853, 30844, 30834, 30826, 30818, 30810, 30804, 30798, 30793, 30789, 30785, 30782, 30780, 30779, 30778, 30778, 30780, 30781, 30783, 30786, 30790, 30794, 30798, 30804, 30812, 30819, 30826, 30834, 30844, 30853, 30864, 30873, 30885, 30900, 30912, 30926, 30940, 30955, 30970, 30986, 31004, 31022, 31039, 31058, 31078, 31046, 31332, 29636, 26804, 25588, 24498, 23590, 22792, 22074, 21420, 20815, 20252, 19725, 19230, 18761, 18317, 17894, 17492, 17109, 16742, 16390, 16054, 15732, 15423, 15126, 14840, 14568, 14304, 13649, 13103, 12679, 12275, 11897, 11534, 11184, 10846, 10517, 10198, 9887, 9584, 9286, 8997, 8715, 8437, 8166, 7899, 7638, 7383, 7133, 6888, 6648, 6412, 6180, 5954, 5732, 5514, 5301, 5091, 4886, 4685, 4489, 4296, 4109, 3924, 3743, 3568, 3395, 3227, 3063, 2904, 2747, 2595, 2448, 2303, 2163, 2027, 1896, 1768, 1646, 1526, 1411, 1301, 1195, 1091, 994, 902, 811, 726, 646, 570, 499, 432, 369, 311, 259, 210, 168, 129, 95, 67, 43, 24, 11, 2, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0};