/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0507 256 samples */
 
const int16_t AKWF_0507_256_DATA [256] = 
{32763, 32766, 32767, 32768, 32768, 32767, 32766, 32764, 32760, 32757, 32753, 32749, 32744, 32739, 32734, 32728, 31942, 36184, 606, -19559, -15490, -16239, -16242, -16244, -16246, -16247, -16248, -16249, -16248, -16247, -16246, -16245, -16244, -15807, -18244, -7740, 33800, 32515, 32660, 32698, 32696, 32694, 32692, 32688, 32684, 32680, 32675, 32670, 32664, 32659, 32653, 32622, 32336, 34212, -6715, -18525, -15839, -16322, -16324, -16327, -16328, -16330, -16331, -16330, -16330, -16331, -16329, -16328, -15870, -18434, -7283, 33959, 32367, 32581, 32612, 32610, 32608, 32605, 32602, 32598, 32593, 32588, 32583, 32578, 32572, 32565, 32560, 32553, 32546, 32539, 32532, 32525, 32518, 32510, 32503, 32495, 32487, 32479, 32472, 32463, 32455, 32447, 32438, 32431, 32423, 32415, 32406, 32398, 32389, 32381, 32372, 32364, 32355, 32347, 32338, 32330, 32321, 31415, 36205, 6144, -20484, -15771, -16657, -16662, -16665, -16669, -16670, -16672, -16674, -16673, -16673, -16674, -16673, -16672, -16671, -16669, -16667, -16665, -16663, -16660, -16657, -16654, -16652, -16649, -16645, -16641, -16638, -16634, -16631, -16627, -16624, -16619, -16615, -16612, -16608, -16604, -16600, -16595, -16592, -16587, -16583, -16579, -16575, -16570, -16566, -16562, -16558, -16553, -16549, -16545, -16541, -16536, -16532, -16527, -16523, -16518, -16514, -16510, -16505, -16501, -16497, -16492, -16488, -16484, -16479, -16475, -16470, -16466, -16461, -16457, -16453, -16448, -16444, -16439, -16435, -16431, -16426, -16422, -16417, -16413, -16408, -16404, -16400, -16395, -16391, -16386, -16382, -16378, -16374, -16369, -16365, -16360, -16356, -16351, -16347, -16343, -16338, -16334, -16330, -16325, -16321, -16317, -16312, -16307, -16304, -16299, -16294, -16290, -16286, -16281, -16277, -16273, -16269, -16264, -16260, -16255, -16251, -16247, -16242, -16238, -16234, -16229, -16225, -16220, -16216, -16211, -16207, -16203, -16199, -16194, -16190, -16185, -16181, -16177, -16172, -16168};