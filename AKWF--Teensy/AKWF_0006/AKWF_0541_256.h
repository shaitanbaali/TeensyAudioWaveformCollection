/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0541 256 samples */
 
const int16_t AKWF_0541_256_DATA [256] = 
{8028, 19104, 21110, 13891, 22836, 20018, 11238, 8339, 25504, 26890, 21041, 10307, 13852, 10379, 4880, 2914, 24824, 31865, 26944, 18976, 23358, 15157, 6966, 402, 14410, 18208, 10004, -1450, 6140, 1427, -2791, 137, 21239, 30674, 30412, 21143, 28022, 23183, 12441, 7662, 23033, 22727, 15304, 3118, 5342, 696, -5831, -8675, 12516, 18992, 13666, 5451, 9738, 1593, -6398, -12626, 1844, 6225, -1285, -11951, -3489, -7256, -10473, -6500, 15678, 26200, 27025, 18832, 26754, 22917, 13122, 9219, 25388, 25790, 18972, 7285, 9891, 5503, -891, -3730, 17332, 23549, 17832, 9100, 12746, 3842, -5019, -12221, 1183, 4415, -4320, -16265, -9129, -14259, -18851, -16259, 4545, 13722, 13243, 3798, 10541, 5605, -5194, -9990, 5402, 5154, -2171, -14222, -11828, -16271, -22560, -25131, -3637, 3173, -1789, -9614, -4905, -12607, -20133, -25872, -10890, -5983, -12948, -23053, -14017, -17198, -19818, -15242, 7548, 18684, 20127, 12553, 21091, 17867, 8683, 5383, 22149, 23135, 16890, 5764, 8917, 5056, -827, -3173, 18360, 25025, 19734, 11401, 15423, 6866, -1674, -8583, 5083, 8545, 13, -11764, -4489, -9513, -14034, -11402, 9410, 18561, 18024, 8486, 15105, 10013, -973, -5988, 9155, 8628, 993, -11394, -9363, -14195, -20900, -23911, -2878, 3449, -2017, -10362, -6192, -14449, -22543, -28861, -14472, -10164, -17736, -28454, -20034, -23833, -27072, -23111, -935, 9593, 10437, 2271, 10231, 6441, -3294, -7130, 9117, 9605, 2884, -8695, -5971, -10235, -16493, -19188, 2028, 8408, 2863, -5688, -1850, -10556, -19210, -26194, -12565, -9101, -17593, -29291, -21897, -26762, -31084, -28211, -7119, 2351, 2173, -6964, 91, -4524, -14995, -19461, -3731, -3634, -10613, -22310, -19556, -23637, -29557, -31756, -9888, -2697, -7275, -14715, -9616, -16926, -24057, -29397, -14017, -8710, -15269, -24970, -15529, -18355, -20584, -15099};