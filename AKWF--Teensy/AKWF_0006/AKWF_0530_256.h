/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0530 256 samples */
 
const int16_t AKWF_0530_256_DATA [256] = 
{18684, 34134, 30043, 29595, 28576, 27556, 26534, 25515, 24495, 23475, 22456, 21435, 20414, 19396, 18375, 17354, 16335, 15315, 14294, 13276, 12255, 11234, 10215, 9194, 8173, 7155, 6135, 5115, 4096, 3074, 2054, 1035, 14, -1005, -2023, -3045, -4064, -5084, -6106, -7124, -8145, -9166, -10184, -11204, -12225, -13244, -14265, -15286, -16304, -17325, -18346, -19363, -20385, -21406, -22424, -23445, -24466, -25484, -26506, -27525, -28544, -29565, -30579, -31612, -32580, -32293, -31629, -31038, -30434, -29829, -29224, -28620, -28015, -27410, -26806, -26201, -25595, -24991, -24387, -23781, -23178, -22572, -21967, -21363, -20758, -20153, -19549, -18944, -18339, -17735, -17129, -16525, -15921, -15315, -14711, -14107, -13501, -12897, -12292, -11687, -11083, -10478, -9873, -9268, -8664, -8058, -7454, -6850, -6244, -5640, -5035, -4430, -3826, -3221, -2616, -2012, -1407, -805, -186, 39, 34, 65, 89, 112, 135, 158, 179, 202, 223, 245, 265, 285, 305, 324, 343, 362, 380, 398, 415, 432, 449, 465, 481, 496, 511, 525, 539, 553, 566, 579, 592, 604, 616, 627, 638, 648, 659, 668, 677, 686, 694, 703, 710, 717, 724, 731, 736, 742, 747, 752, 756, 760, 764, 767, 770, 772, 774, 775, 776, 778, 777, 778, 777, 775, 774, 773, 770, 768, 765, 762, 758, 754, 749, 744, 738, 733, 727, 720, 713, 705, 698, 689, 680, 672, 662, 652, 642, 631, 620, 608, 597, 584, 571, 559, 545, 531, 517, 501, 487, 472, 455, 438, 422, 405, 387, 369, 351, 331, 312, 293, 272, 253, 231, 210, 188, 166, 144, 121, 98, 74, 50, 25, 4, 20, 41, 57, 69, 78, 84, 85, 83, 77, 67, 54, 36, 16};