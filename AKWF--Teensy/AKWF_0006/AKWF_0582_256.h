/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0582 256 samples */
 
const int16_t AKWF_0582_256_DATA [256] = 
{1109, 2856, 4568, 6284, 7998, 9713, 11427, 13140, 14858, 15958, 16776, 17644, 18502, 19358, 20215, 21072, 21927, 22783, 23637, 24489, 25345, 26197, 27048, 27901, 28752, 29602, 30453, 31284, 32215, 32547, 31649, 30778, 29906, 29031, 28157, 27281, 26407, 25532, 24656, 23782, 22906, 22031, 21159, 20284, 19408, 18537, 17662, 16787, 15916, 15043, 14170, 13299, 12427, 11555, 10686, 9794, 9034, 7767, 2176, 2451, 3410, 4195, 5011, 5827, 6645, 7461, 8279, 9098, 9913, 10731, 11548, 12364, 13181, 13999, 14814, 15631, 16448, 17262, 18078, 18895, 19708, 20523, 21338, 22151, 22965, 23779, 24590, 25404, 26218, 27027, 27840, 28105, 31827, 13467, -2428, -542, -1921, -2789, -3656, -4524, -5388, -6253, -7118, -7636, -10374, 2797, 10537, 7017, 5670, 3988, 2302, 615, -1066, -2752, -4437, -6117, -7803, -9486, -11165, -12849, -14532, -16209, -17891, -19570, -21248, -22927, -24603, -26272, -27957, -29905, -29526, -28552, -27708, -26837, -25966, -25095, -24225, -23352, -22482, -21611, -20738, -19868, -18996, -18123, -17255, -16382, -15511, -14642, -13771, -12901, -12033, -11161, -10292, -9425, -8556, -7688, -6821, -5952, -5086, -4220, -3353, -2488, -1623, -758, 102, 977, 1228, 1191, 1204, 1206, 1208, 1209, 1211, 1213, 1215, 1216, 1216, 1218, 1217, 1218, 1219, 1220, 1220, 1220, 1220, 1220, 1220, 1220, 1220, 1220, 1210, 1252, 985, 118, -732, -1584, -2436, -3288, -4142, -4993, -5845, -6698, -7547, -8399, -9251, -10100, -10951, -11802, -12649, -13500, -14351, -15196, -16044, -16894, -17739, -18587, -19433, -20278, -21125, -21971, -22815, -23659, -24504, -25347, -26190, -27032, -27863, -28747, -29392, -28684, -27784, -26931, -26066, -25200, -24336, -23470, -22604, -21740, -20874, -20009, -19146, -18280, -17415, -16553, -15688, -14823, -13953, -13030, -12606, -398, 3539, 3703, 4582, 6086, 316, -1114};