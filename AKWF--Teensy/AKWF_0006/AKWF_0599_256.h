/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0599 256 samples */
 
const int16_t AKWF_0599_256_DATA [256] = 
{175, 487, 791, 1097, 1402, 1707, 2012, 2317, 2622, 2926, 3230, 3535, 3839, 4142, 4447, 4750, 5053, 5356, 5659, 5962, 6266, 6568, 6870, 7173, 7475, 7776, 8079, 8381, 8681, 8982, 9283, 9585, 9886, 10186, 10487, 10787, 11087, 11387, 11687, 11987, 12287, 12585, 12884, 13184, 13482, 13781, 14079, 14378, 14676, 14974, 15272, 15570, 15867, 16165, 16462, 16759, 17056, 17352, 17649, 17946, 18242, 18538, 18835, 19130, 19426, 19721, 20016, 20312, 20606, 20901, 21196, 21490, 21785, 22079, 22373, 22667, 22961, 23254, 23548, 23842, 24133, 24414, 24767, 24441, 23461, 22557, 21641, 20723, 19805, 18890, 17972, 17055, 16140, 15222, 14307, 13391, 12476, 11561, 10647, 9731, 8818, 7905, 6990, 6079, 5166, 4254, 3343, 2432, 1520, 611, -298, -1209, -1703, -4942, 4663, 33734, 30262, 29189, 27775, 26349, 24925, 23502, 22075, 20651, 19226, 17799, 16375, 14950, 13523, 12099, 10675, 9248, 7826, 6402, 4977, 3556, 2134, 710, -708, -2130, -3553, -4970, -6389, -7809, -9225, -10643, -12061, -13475, -14892, -16307, -17718, -19134, -20547, -21957, -23369, -24779, -26188, -27583, -29055, -30125, -29867, -29539, -29231, -28915, -28600, -28284, -27967, -27651, -27334, -27017, -26701, -26383, -26065, -25748, -25431, -25113, -24796, -24478, -24160, -23844, -23526, -23208, -22891, -22574, -22257, -21940, -21622, -21306, -20990, -20673, -20356, -20040, -19723, -19407, -19091, -18775, -18460, -18145, -17829, -17514, -17199, -16884, -16569, -16254, -15940, -15626, -15311, -14997, -14684, -14370, -14056, -13743, -13429, -13116, -12804, -12491, -12178, -11866, -11553, -11241, -10929, -10617, -10306, -9995, -9683, -9372, -9061, -8750, -8439, -8129, -7819, -7509, -7199, -6889, -6580, -6271, -5961, -5652, -5343, -5034, -4726, -4417, -4108, -3801, -3493, -3184, -2877, -2569, -2262, -1956, -1648, -1342, -1034, -728, -423, -111};