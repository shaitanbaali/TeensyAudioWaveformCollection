/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0580 256 samples */
 
const int16_t AKWF_0580_256_DATA [256] = 
{97, 102, 107, 112, 116, 120, 122, 127, 129, 131, 134, 135, 138, 140, 141, 142, 144, 145, 146, 146, 147, 149, 148, 150, 151, 150, 152, 153, 152, 153, 152, 153, 156, 159, 138, 1170, 2715, 4172, 5648, 7119, 8592, 10067, 11536, 13009, 14483, 15952, 17423, 18894, 20361, 21831, 23300, 24765, 26233, 27701, 29163, 30599, 32205, 32087, 30445, 28994, 27510, 26022, 24536, 23051, 21563, 20077, 18593, 17105, 15620, 14135, 12648, 11166, 9681, 8196, 6716, 5232, 3749, 2287, 727, -209, -165, -180, -186, -189, -194, -198, -200, -204, -206, -208, -210, -212, -214, -216, -216, -218, -220, -221, -221, -221, -223, -224, -224, -226, -225, -225, -226, -237, -200, -384, -1607, -2945, -4252, -5568, -6884, -8196, -9513, -10828, -12139, -13453, -14766, -16077, -17390, -18701, -20010, -21322, -22631, -23939, -25249, -26546, -27878, -29084, -28245, -26843, -25465, -23882, -22589, -21280, -19975, -18668, -17360, -16054, -14745, -13431, -12195, -10894, -9563, -8242, -6907, -5654, -4058, 263, 548, 3124, 4871, 6089, 7391, 8683, 9974, 11264, 12557, 13845, 15135, 16425, 17711, 18998, 20286, 21570, 22856, 24141, 25423, 26678, 28095, 28116, 26687, 25416, 24118, 22818, 21517, 20218, 18917, 17615, 16318, 15016, 13716, 12418, 11117, 9818, 8521, 7221, 5924, 4628, 3329, 2048, 689, -191, -167, -177, -183, -186, -190, -192, -195, -198, -200, -202, -204, -205, -207, -210, -219, -176, -1096, -2599, -4009, -5439, -6865, -8291, -9719, -11145, -12569, -13997, -15421, -16844, -18269, -19692, -21113, -22538, -23957, -25378, -26800, -28217, -29603, -31171, -31230, -29651, -28242, -26805, -25366, -23925, -22488, -21047, -19607, -18170, -16730, -15291, -13855, -12415, -10977, -9542, -8103, -6666, -5232, -3798, -2368, -909};