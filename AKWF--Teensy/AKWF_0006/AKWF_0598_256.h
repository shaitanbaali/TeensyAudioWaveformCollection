/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0598 256 samples */
 
const int16_t AKWF_0598_256_DATA [256] = 
{728, 3365, 5926, 8455, 10926, 13328, 15645, 17854, 19950, 21918, 23738, 25409, 26917, 28247, 29399, 30363, 31132, 31704, 32076, 32247, 32214, 31981, 31551, 30924, 30108, 29111, 27934, 26593, 25094, 23444, 21662, 19757, 17736, 15623, 13426, 11156, 8837, 6478, 4092, 1704, -680, -3046, -5368, -7645, -9858, -11987, -14030, -15970, -17791, -19494, -21061, -22482, -23755, -24872, -25823, -26611, -27227, -27670, -27939, -28036, -27959, -27711, -27296, -26719, -25982, -25095, -24063, -22891, -21595, -20178, -18648, -17026, -15309, -13552, -11527, -9411, -7595, -5394, -3292, -3221, 8260, -4625, -1969, 4105, 5689, 7734, 9460, 10915, 12091, 12993, 13630, 14006, 14133, 14025, 13695, 13161, 12439, 11551, 10515, 9353, 8089, 6745, 5340, 3903, 2452, 1008, -401, -1764, -3059, -4267, -5377, -6371, -7237, -7969, -8557, -8993, -9277, -9406, -9382, -9205, -8881, -8418, -7822, -7106, -6280, -5355, -4351, -3281, -2162, -992, 89, 853, 1596, 2335, 3061, 3768, 4455, 5117, 5749, 6348, 6910, 7430, 7907, 8336, 8713, 9036, 9302, 9508, 9651, 9731, 9744, 9691, 9569, 9379, 9119, 8792, 8397, 7935, 7410, 6822, 6173, 5469, 4712, 3905, 3055, 2165, 1240, 291, -682, -1671, -2667, -3667, -4662, -5642, -6604, -7538, -8436, -9294, -10103, -10854, -11544, -12164, -12709, -13175, -13554, -13843, -14039, -14137, -14135, -14031, -13824, -13514, -13100, -12585, -11968, -11254, -10463, -9453, -8994, -7766, -6919, -5735, -4480, -2830, -3087, 8023, -4682, -2107, 4662, 6968, 10103, 13143, 16083, 18841, 21348, 23557, 25407, 26850, 27855, 28391, 28438, 27988, 27042, 25609, 23705, 21366, 18623, 15516, 12110, 8450, 4598, 634, -3390, -7402, -11316, -15084, -18632, -21888, -24809, -27335, -29416, -31025, -32125, -32696, -32727, -32216, -31170, -29601, -27539, -25020, -22075, -18764, -15142, -11265, -7210, -2947};