/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0543 256 samples */
 
const int16_t AKWF_0543_256_DATA [256] = 
{7555, 21110, 18380, 22664, 14904, 17946, 17334, 22763, 15523, 17889, 16922, 21362, 13746, 17361, 16679, 20941, 13183, 16295, 15389, 20964, 13835, 15985, 14953, 19499, 11360, 15460, 14862, 19764, 12582, 14206, 13492, 18396, 9660, 14712, 13825, 17803, 10037, 13079, 12467, 17896, 10656, 13021, 12054, 16497, 8880, 12494, 11812, 16075, 8315, 11428, 10521, 16097, 8967, 11117, 10086, 14633, 6494, 10594, 9997, 14896, 7714, 9312, 8823, 12726, 3131, 10152, 8894, 12935, 5173, 8214, 7602, 13031, 5790, 8155, 7190, 11630, 4016, 7629, 6946, 11208, 3449, 6561, 5655, 11232, 4102, 6252, 5221, 9767, 1629, 5728, 5129, 10030, 2849, 4474, 3758, 8663, -72, 4979, 4093, 8070, 305, 3348, 2737, 8163, 923, 3288, 2322, 6762, -852, 2764, 2079, 6340, -1417, 1696, 789, 6364, -763, 1387, 354, 4898, -3238, 861, 265, 5163, -2020, -484, -437, 1075, -9726, 1070, -969, 3199, -4562, -1517, -2129, 3298, -3943, -1576, -2543, 1896, -5717, -2101, -2786, 1475, -6283, -3170, -4077, 1499, -5628, -3479, -4511, 33, -8103, -4005, -4602, 296, -6883, -5259, -5974, -1068, -9803, -4752, -5638, -1661, -9427, -6383, -6995, -1570, -8808, -6444, -7409, -2969, -10582, -6969, -7652, -3391, -11148, -8035, -8942, -3367, -10495, -8346, -9378, -4832, -12972, -8870, -9468, -4568, -11750, -10150, -10641, -6740, -16333, -9310, -10571, -6529, -14293, -11250, -11861, -6434, -13673, -11307, -12275, -7834, -15449, -11836, -12517, -8255, -16013, -12901, -13808, -8231, -15360, -13211, -14243, -9698, -17836, -13736, -14334, -9434, -16616, -14991, -15706, -10801, -19537, -14485, -15371, -11393, -19160, -16115, -16727, -11301, -18541, -16174, -17141, -12701, -20314, -16701, -17385, -13123, -20880, -17767, -18674, -13100, -20227, -18079, -19110, -14563, -22703, -18602, -19199, -14299, -21484, -19833, -20629, -15613};