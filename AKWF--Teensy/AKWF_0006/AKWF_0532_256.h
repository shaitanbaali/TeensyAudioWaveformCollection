/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0532 256 samples */
 
const int16_t AKWF_0532_256_DATA [256] = 
{6471, 11879, 10873, 11062, 11063, 11063, 11064, 11064, 11063, 11063, 11063, 11062, 11060, 11059, 11058, 11056, 11054, 11053, 11050, 11048, 11046, 11044, 11041, 11039, 11037, 11034, 11032, 11030, 11027, 11025, 11021, 11018, 11016, 11013, 11012, 11007, 11004, 11002, 11000, 10997, 10993, 10991, 10988, 10986, 10982, 10980, 10979, 10974, 10971, 10969, 10966, 10962, 10960, 10958, 10953, 10951, 10949, 10945, 10942, 10940, 10937, 10933, 10931, 10928, 10924, 10921, 10934, 11103, 10008, 25062, 33740, 32225, 32500, 32495, 32490, 32485, 32478, 32472, 32466, 32459, 32452, 32445, 32438, 32431, 32424, 32417, 32409, 32401, 32393, 32386, 32379, 32370, 32363, 32354, 32346, 32338, 32329, 32320, 32312, 32304, 32295, 32288, 32279, 32271, 32263, 32253, 32244, 32237, 32229, 32220, 32210, 32202, 32194, 32184, 32176, 32167, 32160, 32151, 32142, 32134, 32125, 32117, 32107, 32099, 32091, 32016, 31904, 32823, 5781, -29989, -33333, -32537, -32766, -32767, -32767, -32768, -32767, -32767, -32766, -32764, -32760, -32756, -32751, -32747, -32741, -32736, -32731, -32724, -32718, -32712, -32706, -32698, -32691, -32683, -32676, -32669, -32662, -32654, -32646, -32637, -32630, -32623, -32615, -32607, -32597, -32590, -32581, -32573, -32565, -32556, -32549, -32540, -32531, -32522, -32514, -32506, -32498, -32490, -32480, -32471, -32463, -32455, -32445, -32418, -32353, -32732, -24035, -11890, -10574, -10869, -10779, -10772, -10765, -10760, -10754, -10748, -10742, -10738, -10733, -10728, -10724, -10719, -10714, -10711, -10708, -10703, -10699, -10696, -10692, -10689, -10685, -10681, -10678, -10674, -10671, -10668, -10665, -10661, -10659, -10655, -10652, -10649, -10646, -10643, -10640, -10636, -10634, -10630, -10628, -10626, -10623, -10619, -10617, -10615, -10610, -10608, -10605, -10602, -10599, -10596, -10594, -10589, -10587, -10585, -10581, -10578, -10576, -10573, -10569, -10567, -10565, -10562, -10558, -10555, -10554, -10550};