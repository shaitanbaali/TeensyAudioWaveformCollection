/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0559 256 samples */
 
const int16_t AKWF_0559_256_DATA [256] = 
{-340, -3402, -9065, -15773, -22204, -27460, -31007, -32640, -32441, -30662, -27678, -23891, -19705, -15490, -11513, -7989, -5055, -2746, -1063, 43, 664, 898, 846, 610, 274, -91, -435, -724, -938, -1074, -1135, -1130, -1077, -991, -886, -778, -674, -585, -514, -462, -427, -410, -407, -414, -425, -440, -453, -463, -467, -465, -458, -444, -424, -398, -368, -334, -297, -258, -217, -174, -130, -85, -39, 7, 55, 104, 154, 205, 257, 311, 365, 421, 477, 534, 592, 651, 709, 768, 828, 888, 947, 1006, 1067, 1126, 1185, 1244, 1303, 1362, 1419, 1476, 1533, 1589, 1645, 1699, 1754, 1807, 1859, 1911, 1962, 2012, 2061, 2108, 2156, 2201, 2246, 2290, 2332, 2374, 2413, 2452, 2490, 2527, 2562, 2596, 2629, 2660, 2690, 2719, 2746, 2772, 2797, 2820, 2843, 2864, 2883, 2902, 2919, 2934, 2949, 2962, 2973, 2984, 2993, 3001, 3008, 3013, 3017, 3020, 3022, 3023, 3022, 3020, 3017, 3013, 3008, 3001, 2993, 2985, 2976, 2965, 2953, 2941, 2927, 2913, 2897, 2881, 2864, 2846, 2826, 2807, 2786, 2765, 2742, 2720, 2696, 2672, 2647, 2622, 2596, 2569, 2541, 2514, 2486, 2456, 2427, 2397, 2366, 2336, 2305, 2274, 2242, 2211, 2179, 2146, 2113, 2079, 2046, 2013, 1979, 1946, 1912, 1878, 1844, 1810, 1775, 1741, 1707, 1673, 1638, 1604, 1571, 1536, 1503, 1468, 1435, 1401, 1368, 1334, 1301, 1269, 1235, 1203, 1171, 1139, 1107, 1076, 1045, 1014, 984, 953, 923, 894, 864, 836, 807, 780, 752, 724, 697, 671, 645, 619, 593, 569, 544, 520, 497, 473, 451, 428, 406, 385, 364, 344, 323, 303, 285, 266, 248, 230, 213, 197, 180, 164, 148, 133};