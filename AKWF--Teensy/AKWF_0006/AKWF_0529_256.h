/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0529 256 samples */
 
const int16_t AKWF_0529_256_DATA [256] = 
{162, 162, 162, 162, 162, 162, 162, 162, 162, 162, 162, 162, 162, 162, 162, 162, 162, 162, 162, 162, 162, 162, 162, 162, 162, 162, 162, 162, 162, 162, 162, 162, 735, -2347, 14447, 35345, 32176, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32572, 33664, 29012, 9297, 9752, 9719, 9696, 9696, 9696, 9696, 9696, 9696, 9696, 9696, 9696, 9696, 9696, 9696, 9696, 9696, 9696, 9696, 9675, 9786, 9217, 8355, 8470, 8449, 8449, 8449, 8449, 8449, 8449, 8449, 8449, 8449, 8449, 8449, 8449, 8449, 8449, 8449, 8449, 8449, 8449, 8449, 8449, 8334, 8957, 3952, 967, 1563, 1454, 1454, 1454, 1454, 1454, 1454, 1454, 1454, 1454, 1454, 1454, 1454, 1454, 1454, 1454, 1454, 1451, 1454, 1462, 181, -81, -18, -29, -29, -29, -29, -29, -29, -29, -29, -29, -29, -29, -29, -29, -29, -29, -29, -29, -29, -29, -41, 24, -250, -1494, -1475, -1475, -1476, -1476, -1476, -1476, -1476, -1476, -1476, -1476, -1476, -1476, -1476, -1476, -1476, -1476, -1476, -1476, -1495, -1420, -1655, -7560, -8363, -8185, -8244, -8264, -8286, -8306, -8327, -8348, -8369, -8390, -8412, -8433, -8447, -8461, -8475, -8489, -8502, -8517, -8530, -8545, -8558, -8572, -8589, -8594, -8631, -9693, -9861, -9820, -9827, -9827, -9827, -9827, -9827, -9827, -9827, -9827, -9827, -9827, -9827, -9827, -9827, -9827, -9827, -9827, -10234, -8047, -23327, -34457, -32351, -32741, -32741, -32741, -32741, -32741, -32741, -32741, -32741, -32741, -32741, -32741, -32741, -32741, -32741, -32741, -32741, -32741, -32741, -32741, -32741, -32741, -32741, -32741, -32741, -32741, -32741};