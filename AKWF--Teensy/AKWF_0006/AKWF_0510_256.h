/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0510 256 samples */
 
const int16_t AKWF_0510_256_DATA [256] = 
{325, 1537, 2723, 3906, 5082, 6250, 7410, 8552, 9681, 10795, 11887, 12962, 14014, 15040, 16046, 17024, 17972, 18895, 19787, 20647, 21478, 22277, 23041, 23775, 24475, 25140, 25774, 26374, 26940, 27474, 27975, 28445, 28884, 29290, 29668, 30017, 30337, 30632, 30900, 31144, 31364, 31563, 31739, 31897, 32035, 32158, 32263, 32356, 32434, 32501, 32558, 32605, 32642, 32674, 32699, 32718, 32733, 32744, 32753, 32759, 32763, 32765, 32767, 32768, 32768, 32767, 32766, 32764, 32761, 32755, 32748, 32738, 32725, 32707, 32685, 32656, 32622, 32579, 32527, 32464, 32391, 32304, 32205, 32090, 31958, 31809, 31641, 31452, 31241, 31008, 30749, 30467, 30157, 29820, 29455, 29061, 28636, 28179, 27691, 27171, 26620, 26034, 25414, 24763, 24078, 23358, 22607, 21822, 21005, 20158, 19279, 18369, 17433, 16466, 15472, 14456, 13413, 12348, 11264, 10158, 9036, 7900, 6746, 5582, 4409, 3227, 2040, 850, -343, -1533, -2722, -3907, -5083, -6251, -7411, -8553, -9682, -10796, -11888, -12962, -14015, -15041, -16046, -17024, -17973, -18895, -19787, -20647, -21478, -22277, -23041, -23775, -24475, -25140, -25775, -26374, -26940, -27474, -27975, -28445, -28884, -29290, -29668, -30017, -30338, -30632, -30900, -31144, -31364, -31563, -31739, -31897, -32035, -32158, -32263, -32356, -32434, -32501, -32558, -32605, -32642, -32674, -32699, -32718, -32733, -32744, -32753, -32759, -32763, -32765, -32767, -32768, -32768, -32767, -32766, -32764, -32761, -32755, -32748, -32738, -32725, -32707, -32685, -32656, -32622, -32579, -32527, -32464, -32391, -32304, -32205, -32090, -31958, -31809, -31641, -31452, -31241, -31008, -30750, -30467, -30157, -29821, -29455, -29061, -28636, -28179, -27692, -27172, -26620, -26034, -25415, -24764, -24078, -23358, -22608, -21823, -21005, -20159, -19279, -18370, -17433, -16467, -15472, -14456, -13414, -12348, -11265, -10158, -9036, -7900, -6747, -5582, -4410, -3230, -2046, -835};