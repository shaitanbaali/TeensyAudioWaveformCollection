/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0597 256 samples */
 
const int16_t AKWF_0597_256_DATA [256] = 
{806, 2286, 3734, 5181, 6616, 8041, 9452, 10840, 12208, 13553, 14866, 16150, 17401, 18613, 19788, 20921, 22007, 23049, 24042, 24982, 25871, 26705, 27482, 28202, 28862, 29459, 29998, 30473, 30884, 31232, 31515, 31733, 31887, 31975, 31999, 31957, 31852, 31684, 31453, 31160, 30806, 30393, 29923, 29395, 28811, 28176, 27487, 26748, 25964, 25133, 24258, 23344, 22388, 21398, 20374, 19318, 18234, 17126, 15991, 14838, 13668, 12481, 11284, 10078, 8862, 7646, 6428, 5210, 3999, 2795, 1599, 419, -747, -1909, -2975, -4055, -5051, -5927, -6821, -7553, -8256, -8885, -9433, -9907, -10319, -10676, -10984, -11251, -11479, -11672, -11832, -11961, -12060, -12132, -12177, -12196, -12190, -12160, -12106, -12030, -11933, -11813, -11672, -11512, -11332, -11133, -10916, -10680, -10428, -10159, -9873, -9572, -9255, -8924, -8579, -8220, -7849, -7464, -7068, -6659, -6240, -5811, -5372, -4924, -4467, -4000, -3527, -3047, -2560, -2069, -1568, -1049, -526, 0, 527, 1056, 1585, 2113, 2640, 3164, 3685, 4199, 4709, 5211, 5705, 6190, 6666, 7128, 7578, 8015, 8435, 8840, 9226, 9593, 9941, 10267, 10570, 10850, 11104, 11332, 11533, 11705, 11848, 11961, 12043, 12091, 12107, 12089, 12036, 11949, 11826, 11666, 11470, 11238, 10967, 10660, 10316, 9935, 9517, 9064, 8574, 8048, 7489, 6896, 6269, 5611, 4922, 4203, 3458, 2685, 1888, 1068, 225, -636, -1514, -2410, -3324, -4184, -5388, -6198, -7520, -8584, -9856, -11169, -12490, -13859, -15262, -16659, -18048, -19422, -20763, -22058, -23306, -24494, -25615, -26671, -27652, -28554, -29378, -30116, -30767, -31330, -31803, -32182, -32468, -32661, -32757, -32758, -32664, -32475, -32190, -31813, -31342, -30779, -30128, -29388, -28561, -27653, -26662, -25593, -24452, -23236, -21952, -20606, -19196, -17730, -16215, -14647, -13037, -11391, -9705, -7993, -6258, -4503, -2738, -928};