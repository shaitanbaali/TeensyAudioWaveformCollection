/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0577 256 samples */
 
const int16_t AKWF_0577_256_DATA [256] = 
{849, 2556, 4229, 5908, 7584, 9260, 10940, 12614, 14291, 15968, 17783, 18651, 26685, 30399, 28777, 28200, 27456, 26711, 25964, 25219, 24471, 23724, 22978, 22230, 21482, 20735, 19987, 19239, 18492, 17744, 16998, 16250, 15502, 14756, 14010, 13263, 12517, 11771, 11024, 10280, 9534, 8789, 8046, 7301, 6556, 5814, 5070, 4326, 3585, 2842, 2100, 1360, 618, -120, -863, -1591, -1761, -1733, -1742, -1744, -1746, -1747, -1748, -1750, -1750, -1751, -1750, -1750, -1750, -1750, -1750, -1750, -1750, -1750, -1750, -1750, -1751, -1750, -1749, -1750, -1749, -1747, -1748, -1747, -1745, -1746, -1744, -1744, -1743, -1741, -1741, -1741, -1740, -1739, -1738, -1737, -1737, -1736, -1734, -1734, -1734, -1733, -1731, -1731, -1729, -1729, -1727, -1727, -1726, -1725, -1725, -1724, -1722, -1722, -1721, -1720, -1719, -1718, -1716, -1716, -1716, -1715, -1714, -1713, -1711, -1711, -1710, -1709, -1708, -1707, -1707, -1706, -1704, -1704, -1703, -1702, -1700, -1700, -1700, -1699, -1698, -1697, -1695, -1695, -1693, -1693, -1692, -1691, -1691, -1690, -1688, -1688, -1687, -1686, -1684, -1684, -1682, -1682, -1682, -1681, -1680, -1679, -1677, -1677, -1675, -1675, -1674, -1673, -1673, -1672, -1670, -1670, -1669, -1668, -1667, -1666, -1664, -1664, -1664, -1663, -1662, -1662, -1660, -1659, -1658, -1657, -1657, -1657, -1655, -1655, -1664, -1616, -1908, -2864, -3801, -4740, -5679, -6619, -7559, -8497, -9435, -10374, -11311, -12249, -13187, -14123, -15060, -15997, -16931, -17867, -18804, -19737, -20672, -21606, -22538, -23472, -24405, -25336, -26269, -27199, -28128, -29060, -29989, -30485, -33790, -23470, 1197, -376, 785, 1531, 2277, 3020, 3763, 4507, 5248, 5989, 6731, 7470, 8208, 8947, 9684, 10423, 11160, 11880, 12452, 14314, -9968, -15598, -12255, -10877, -9196, -7518, -5840, -4162, -2488, -780};