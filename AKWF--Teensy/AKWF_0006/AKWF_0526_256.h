/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0526 256 samples */
 
const int16_t AKWF_0526_256_DATA [256] = 
{-296, 1432, 5054, 5405, 6020, 8912, 10713, 14527, 15025, 15495, 18385, 19644, 20353, 20434, 20422, 20425, 20425, 20425, 20425, 20425, 20418, 20468, 19520, 19436, 20436, 20481, 20182, 23034, 24416, 24127, 24179, 24175, 24175, 24223, 20996, 20268, 20539, 19894, 19448, 16590, 15235, 14838, 13236, 10567, 10154, 9492, 5577, 3856, 1044, 564, -111, 133, -473, -3650, -4165, -4970, -4124, -3526, -296, 94, -104, 607, 1195, 916, 1692, 4900, 4825, 4831, 4835, 4835, 4835, 4770, 5118, 2522, 798, 1193, 788, 257, -1852, -4038, -4393, -5488, -9331, -11103, -13629, -14048, -14707, -17931, -18343, -18241, -18260, -18269, -18221, -18425, -19356, -19342, -19359, -19276, -19606, -22842, -23545, -23947, -26426, -28220, -27821, -28145, -29051, -29044, -28846, -31901, -32961, -32726, -32767, -32767, -32767, -32724, -32968, -31836, -28915, -28451, -27944, -24177, -22121, -18639, -16206, -13319, -10225, -7732, -857, 1569, 5019, 5405, 6020, 8912, 10713, 14527, 15025, 15495, 18385, 19644, 20353, 20434, 20422, 20425, 20425, 20425, 20425, 20425, 20418, 20468, 19520, 19436, 20436, 20481, 20182, 23034, 24416, 24127, 24179, 24175, 24175, 24223, 20996, 20268, 20539, 19894, 19448, 16590, 15235, 14838, 13236, 10567, 10154, 9492, 5577, 3856, 1044, 564, -111, 133, -473, -3650, -4165, -4970, -4124, -3526, -296, 94, -104, 607, 1195, 916, 1692, 4900, 4825, 4831, 4835, 4835, 4835, 4770, 5118, 2522, 798, 1193, 788, 257, -1852, -4038, -4393, -5488, -9331, -11103, -13629, -14048, -14707, -17931, -18343, -18241, -18260, -18269, -18221, -18425, -19356, -19342, -19359, -19276, -19606, -22842, -23545, -23947, -26426, -28220, -27821, -28145, -29051, -29044, -28846, -31901, -32961, -32726, -32767, -32767, -32767, -32724, -32968, -31836, -28915, -28451, -27944, -24177, -22121, -18639, -16206, -13354, -10088, -8293};