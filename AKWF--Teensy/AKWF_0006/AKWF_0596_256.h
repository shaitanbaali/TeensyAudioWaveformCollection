/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0596 256 samples */
 
const int16_t AKWF_0596_256_DATA [256] = 
{2205, 9007, 14945, 19717, 23016, 24724, 24877, 23612, 21117, 17649, 13530, 9045, 4472, 64, -4007, -7581, -10501, -12660, -13987, -14478, -14162, -13109, -11416, -9171, -6472, -3435, -239, 2182, 4304, 6424, 8442, 10321, 11962, 13259, 14166, 14671, 14773, 14497, 13883, 12959, 11724, 10205, 8452, 6499, 4380, 2137, -208, -2622, -5043, -7412, -9650, -11699, -13511, -15037, -16245, -17100, -17533, -17499, -16989, -16002, -14543, -12625, -10289, -7550, -4389, -1336, 5641, 14394, 19592, 20702, 17580, 11041, 2522, -6158, -13206, -17294, -17692, -14452, -8136, -582, 2759, 4975, 7280, 9367, 11274, 12992, 14535, 15918, 17115, 18108, 18894, 19459, 19776, 19817, 19556, 18941, 17886, 16358, 14429, 12192, 9715, 7052, 4259, 1390, -1525, -4439, -7293, -10066, -12716, -15206, -17524, -19627, -21435, -22897, -23979, -24663, -24940, -24805, -24270, -23327, -21958, -20166, -17971, -15416, -12536, -9360, -5913, -2460, 2257, 8992, 14940, 19718, 23017, 24725, 24878, 23613, 21117, 17650, 13531, 9046, 4473, 65, -4006, -7580, -10500, -12659, -13987, -14477, -14161, -13108, -11415, -9170, -6471, -3434, -238, 2183, 4305, 6425, 8443, 10322, 11963, 13260, 14167, 14672, 14774, 14498, 13884, 12960, 11725, 10206, 8453, 6500, 4381, 2138, -207, -2621, -5043, -7411, -9650, -11698, -13510, -15036, -16244, -17099, -17532, -17498, -16988, -16001, -14542, -12624, -10288, -7549, -4388, -1335, 5642, 14395, 19593, 20703, 17581, 11042, 2523, -6157, -13205, -17293, -17691, -14451, -8133, -591, 2618, 4718, 6977, 9087, 11081, 12933, 14634, 16174, 17504, 18585, 19404, 19946, 20193, 20131, 19757, 19040, 17908, 16356, 14430, 12193, 9715, 7052, 4259, 1389, -1527, -4441, -7296, -10069, -12722, -15212, -17530, -19633, -21442, -22904, -23985, -24668, -24944, -24808, -24270, -23326, -21955, -20161, -17965, -15410, -12530, -9361, -5961, -2283};