/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0595 256 samples */
 
const int16_t AKWF_0595_256_DATA [256] = 
{4564, 11752, 18700, 26098, 31530, 25759, 18400, 11503, 4068, -566, -371, -412, -425, -428, -432, -434, -436, -438, -440, -442, -444, -445, -446, -447, -498, -280, -1609, -6242, -10813, -15304, -20302, -19746, -14666, -10207, -5578, -1161, -308, -468, -425, -423, -421, -419, -417, -416, -414, -413, -412, -410, -409, -408, -407, -407, -405, -404, -404, -404, -403, -403, -402, -400, -401, -400, -399, -392, -419, -291, 785, 2007, 3166, 4483, 4880, 3626, 2442, 1257, 18, -450, -388, -418, -348, -838, -2206, -3520, -4828, -6233, -5853, -4389, -3103, -1751, -536, -373, -406, -395, -394, -394, -393, -393, -392, -393, -391, -390, -391, -390, -389, -390, -389, -387, -388, -388, -387, -386, -387, -386, -387, -386, -385, -384, -385, -385, -384, -384, -383, -384, -383, -384, -383, -370, -351, -479, 4391, 11800, 18688, 26098, 31530, 25759, 18400, 11503, 4068, -566, -371, -412, -425, -428, -431, -434, -436, -438, -440, -442, -443, -445, -446, -447, -498, -280, -1609, -6242, -10813, -15303, -20301, -19746, -14666, -10207, -5578, -1161, -308, -468, -425, -423, -421, -419, -417, -416, -414, -413, -412, -410, -409, -408, -407, -406, -405, -404, -404, -404, -403, -403, -402, -400, -401, -400, -399, -392, -419, -290, 785, 2008, 3167, 4483, 4880, 3626, 2442, 1257, 18, -450, -388, -418, -348, -838, -2206, -3520, -4828, -6233, -5853, -4389, -3103, -1751, -536, -372, -405, -395, -394, -394, -393, -393, -393, -392, -390, -391, -390, -389, -389, -390, -389, -387, -388, -388, -387, -386, -387, -386, -387, -385, -384, -385, -384, -385, -384, -383, -384, -383, -383, -384, -383, -382, -383, -382};