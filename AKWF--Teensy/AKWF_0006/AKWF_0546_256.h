/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0546 256 samples */
 
const int16_t AKWF_0546_256_DATA [256] = 
{2669, 6891, 10764, 14279, 17327, 19841, 21794, 23155, 23937, 24321, 24534, 24713, 24905, 25105, 25274, 25330, 25195, 24884, 24464, 23957, 23345, 22618, 21747, 20674, 19392, 18035, 16792, 15768, 14962, 14322, 13777, 13217, 12550, 11793, 10991, 10148, 9236, 8217, 7068, 5747, 4230, 2656, 1217, -1, -991, -1789, -2477, -3157, -3931, -4809, -5731, -6688, -7709, -8811, -10026, -11417, -12949, -14259, -14883, -14561, -13286, -11199, -8541, -5602, -2645, 181, 2807, 5159, 7145, 8709, 9826, 10459, 10616, 10460, 10216, 10006, 9865, 9782, 9706, 9549, 9227, 8750, 8181, 7543, 6810, 5970, 4998, 3831, 2492, 1267, 533, 494, 1157, 2411, 4071, 5908, 7717, 9405, 10940, 12274, 13336, 14080, 14478, 14494, 14123, 13525, 12909, 12387, 11985, 11684, 11422, 11109, 10652, 10055, 9382, 8650, 7832, 6915, 5872, 4639, 3238, 1956, 1166, 1078, 1697, 2910, 4533, 6334, 8111, 9766, 11272, 12581, 13619, 14340, 14718, 14713, 14326, 13711, 13079, 12545, 12130, 11817, 11545, 11221, 10755, 10151, 9469, 8730, 7907, 6984, 5934, 4697, 3260, 1762, 386, -758, -1678, -2424, -3067, -3717, -4466, -5301, -6175, -7083, -8055, -9129, -10329, -11698, -13256, -14869, -16346, -17597, -18618, -19445, -20158, -20864, -21659, -22556, -23498, -24471, -25509, -26626, -27853, -29257, -30800, -32122, -32754, -32442, -31175, -29095, -26443, -23510, -20558, -17739, -15117, -12768, -10788, -9227, -8114, -7484, -7331, -7488, -7734, -7947, -8091, -8175, -8253, -8412, -8736, -9214, -9784, -10425, -11158, -11998, -12972, -14138, -15479, -16704, -17441, -17480, -16816, -15564, -13904, -12067, -10258, -8571, -7037, -5702, -4641, -3897, -3498, -3484, -3854, -4454, -5070, -5590, -5994, -6294, -6556, -6870, -7328, -7923, -8597, -9330, -10147, -11064, -12107, -13340, -14707, -15773, -15979, -15012, -12863, -9705, -5835, -1509};