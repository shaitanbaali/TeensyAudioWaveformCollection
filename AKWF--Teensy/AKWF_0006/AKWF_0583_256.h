/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0583 256 samples */
 
const int16_t AKWF_0583_256_DATA [256] = 
{658, 2408, 4121, 5840, 7557, 9274, 10994, 12709, 14427, 16200, 17592, 20587, 30029, 29425, 28457, 27614, 26742, 25867, 24990, 24117, 23240, 22364, 21490, 20613, 19737, 18645, 19000, 12404, -1215, 908, 1531, 2384, 3239, 4094, 4949, 5805, 6661, 7517, 8374, 9228, 10084, 10942, 11797, 12653, 13509, 14364, 15220, 16076, 16929, 17785, 18640, 19491, 20346, 21200, 22053, 22906, 23759, 24610, 25462, 26313, 27164, 28012, 28857, 29736, 29401, 28442, 27588, 26712, 25839, 24965, 24091, 23218, 22343, 21468, 20595, 19720, 18847, 17975, 17101, 16227, 15357, 14484, 13611, 12741, 11869, 10998, 10129, 9256, 8387, 7519, 6649, 5780, 4912, 4044, 3177, 2311, 1443, 577, -277, -1188, -1665, -1626, -1638, -1641, -1643, -1645, -1647, -1648, -1649, -1651, -1650, -1652, -1654, -1653, -1653, -1653, -1653, -1653, -1653, -1653, -1653, -1653, -1653, -1654, -1652, -1650, -1651, -1650, -1651, -1649, -1648, -1649, -1648, -1646, -1647, -1646, -1645, -1644, -1645, -1643, -1645, -1643, -1643, -2285, -3186, -4041, -4904, -5766, -6629, -7493, -8353, -9216, -10079, -10939, -11801, -12662, -13522, -14383, -15242, -16102, -16961, -17819, -18678, -19536, -20393, -21250, -22108, -22963, -23819, -24675, -25529, -26383, -27239, -28092, -28945, -29799, -30650, -31484, -32422, -32388, -31421, -30562, -29685, -28807, -27927, -27051, -26170, -25292, -24416, -23536, -22658, -21781, -20902, -20026, -19149, -18271, -17396, -16519, -15642, -14767, -13893, -13016, -12142, -11268, -10392, -9427, -9087, -3834, -1746, -3177, -3913, -4757, -5605, -6452, -7298, -8146, -8994, -9840, -10689, -11535, -12381, -13230, -14076, -14921, -15769, -16615, -17460, -18307, -19151, -19960, -20865, -21739, -3233, 1188, 1202, 2227, 3099, 3967, 4838, 5709, 6575, 7444, 8313, 9178, 10045, 10414, 13948, -1925, -15241, -10858, -9636, -7917, -6199, -4480, -2765, -1016};