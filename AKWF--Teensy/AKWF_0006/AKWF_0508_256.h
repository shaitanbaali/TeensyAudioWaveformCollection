/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0508 256 samples */
 
const int16_t AKWF_0508_256_DATA [256] = 
{32740, 32747, 32751, 32755, 32757, 32759, 32758, 32759, 32758, 32756, 32753, 32750, 32747, 32742, 32738, 32733, 32728, 32722, 32716, 32711, 32704, 32698, 32691, 32684, 32676, 32669, 32662, 32655, 32648, 32640, 32632, 32623, 32616, 32607, 32599, 32592, 32583, 32575, 32567, 32558, 32550, 32541, 32534, 32525, 32516, 32508, 32498, 32490, 32483, 32473, 32464, 32457, 32447, 32438, 32431, 32422, 32413, 32405, 32396, 32387, 32378, 32371, 32362, 32352, 32345, 32335, 32326, 32318, 32310, 32301, 32292, 32284, 32275, 32265, 32258, 31269, 36621, 10080, -36742, -31159, -32189, -32192, -32195, -32196, -32197, -32196, -32194, -32193, -32190, -32187, -32183, -32179, -32175, -32169, -32165, -32160, -32153, -32147, -32141, -32136, -32129, -32122, -32115, -32107, -32100, -32092, -32085, -32078, -32070, -32062, -32054, -32047, -32038, -32030, -32023, -32015, -32006, -31998, -31989, -31981, -31973, -31966, -31956, -31949, -31939, -31931, -31922, -31914, -31907, -31897, -31890, -31881, -31871, -31864, -31855, -31847, -31839, -31829, -31822, -31813, -31804, -31797, -31787, -31779, -31771, -31761, -31753, -31745, -31736, -31728, -31720, -31710, -31703, -31693, -31685, -31159, -34032, -21866, 33508, 32686, 32684, 32765, 32767, 32767, 32767, 32768, 32767, 32765, 32763, 32759, 32756, 32752, 32747, 32742, 32737, 32731, 32725, 32719, 32713, 32707, 32700, 32693, 32686, 32678, 32671, 32663, 32656, 32649, 32641, 32632, 32624, 32616, 32608, 32600, 32592, 32584, 32575, 32567, 32559, 32550, 32542, 32533, 32526, 32517, 32120, 34180, 25926, -30652, -32357, -31772, -31934, -31936, -31938, -31938, -31939, -31938, -31936, -31934, -31930, -31927, -31924, -31919, -31915, -31911, -31904, -31899, -31893, -31887, -31880, -31874, -31867, -31860, -31854, -31846, -31839, -31831, -31824, -31816, -31808, -31801, -31793, -31785, -31777, -31769, -31761, -31752, -31745, -31737, -31729, -31720, -31712, -31703, -31695, -31687, -31680, -31670};