/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0521 256 samples */
 
const int16_t AKWF_0521_256_DATA [256] = 
{376, 1776, 3163, 4566, 5976, 7389, 8805, 10213, 11615, 13006, 14376, 15729, 17057, 18353, 19620, 20849, 22034, 23178, 24273, 25313, 26300, 27228, 28091, 28891, 29621, 30280, 30868, 31379, 31812, 32167, 32441, 32633, 32742, 32768, 32711, 32570, 32346, 32038, 31649, 31180, 30630, 30001, 29298, 28521, 27672, 26757, 25774, 24729, 23627, 22468, 21259, 20004, 18703, 17364, 15994, 14591, 13165, 11720, 10256, 8785, 7310, 5830, 4357, 2894, 1443, 12, -1394, -2775, -4120, -5430, -6701, -7924, -9101, -10227, -11294, -12305, -13256, -14139, -14958, -15710, -16390, -16999, -17535, -17996, -18383, -18696, -18933, -19096, -19183, -19197, -19138, -19008, -18807, -18538, -18202, -17805, -17342, -16823, -16248, -15617, -14938, -14212, -13442, -12634, -11789, -10909, -10005, -9073, -8120, -7153, -6170, -5178, -4183, -3184, -2187, -1198, -217, 750, 1702, 2635, 3546, 4430, 5288, 6114, 6905, 7664, 8384, 9063, 9704, 10301, 10853, 11362, 11824, 12240, 12609, 12930, 13204, 13432, 13611, 13743, 13830, 13871, 13867, 13819, 13729, 13597, 13426, 13216, 12969, 12686, 12371, 12022, 11644, 11237, 10801, 10343, 9862, 9358, 8836, 8296, 7739, 7168, 6586, 5990, 5387, 4776, 4157, 3534, 2906, 2274, 1643, 1009, 375, -256, -887, -1516, -2141, -2764, -3384, -3998, -4610, -5215, -5815, -6413, -7004, -7588, -8171, -8745, -9314, -9880, -10439, -10993, -11543, -12086, -12623, -13156, -13682, -14201, -14715, -15221, -15720, -16211, -16694, -17168, -17633, -18086, -18529, -18960, -19376, -19778, -20165, -20534, -20886, -21218, -21529, -21818, -22082, -22321, -22532, -22715, -22867, -22988, -23073, -23125, -23139, -23115, -23050, -22945, -22796, -22603, -22365, -22081, -21748, -21367, -20938, -20458, -19928, -19349, -18717, -18034, -17304, -16520, -15688, -14808, -13878, -12902, -11882, -10816, -9709, -8563, -7376, -6155, -4902, -3617, -2309, -947};