/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0516 256 samples */
 
const int16_t AKWF_0516_256_DATA [256] = 
{5340, 14366, 20459, 22675, 21673, 18377, 14094, 9979, 6759, 4683, 3580, 3432, 2879, 848, -2283, -3787, -2297, 126, -3373, -12582, -22158, -29131, -32628, -31529, -26785, -19967, -12422, -5257, 955, 6122, 10393, 13945, 16846, 18676, 16451, 10866, 4399, 3732, 5631, 8563, 11136, 12282, 11808, 10152, 8088, 6394, 5589, 5648, 5928, 6412, 7058, 6731, 5911, 4874, 3996, 3627, 3969, 5022, 6612, 8454, 10226, 11642, 12455, 12528, 12162, 11708, 11244, 10799, 10406, 10076, 9825, 9673, 9647, 9779, 10092, 10607, 11191, 12345, 14051, 15085, 15784, 16355, 15079, 14097, 14557, 14058, 12940, 11458, 10085, 9096, 8309, 7528, 6763, 6114, 5659, 5350, 5277, 5596, 5503, 5559, 5768, 6082, 6436, 6794, 7170, 7580, 7992, 8474, 9311, 9608, 9769, 10241, 11400, 12869, 14439, 14282, 14923, 16184, 16971, 17271, 17485, 17589, 17527, 17803, 17709, 17135, 16239, 14979, 13859, 13147, 11948, 10747, 9472, 8543, 7697, 6525, 5469, 4674, 4341, 3746, 3579, 3924, 3826, 3858, 4332, 2136, -7943, -13636, -15617, -12989, -4918, -1592, 1118, 629, -5680, -8396, -16882, -21211, -22778, -18780, -19189, -20068, -24248, -28114, -26983, -22192, -16241, -11941, -4674, -2914, -4062, -8104, -7677, -8377, -9900, -9479, -5426, -7372, -8304, -9612, -16691, -18379, -18397, -12674, -12026, -11315, -14987, -17062, -15914, -15898, -16129, -10364, -9561, -10671, -10619, -15840, -19792, -20243, -19502, -14409, -15169, -15581, -15907, -16128, -16237, -16241, -16138, -16009, -15576, -14653, -15922, -16595, -15574, -15375, -15701, -16341, -16856, -17007, -17015, -17151, -17388, -16638, -16555, -16717, -16704, -16656, -16552, -16338, -15991, -15554, -15084, -14608, -14119, -13609, -13099, -12610, -12221, -11436, -10905, -11303, -8240, -3252, -3752, -3592, -3575, -3582, -3601, -3611, -3599, -3573, -3500, -3339, -3152, -3066, -3432, -1738};