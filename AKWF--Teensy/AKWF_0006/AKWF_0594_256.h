/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0594 256 samples */
 
const int16_t AKWF_0594_256_DATA [256] = 
{251, 258, 264, 269, 274, 279, 283, 286, 290, 293, 296, 298, 300, 302, 304, 306, 307, 308, 310, 311, 312, 313, 314, 314, 314, 316, 317, 316, 317, 318, 318, 318, 318, 317, 318, 319, 319, 319, 319, 319, 319, 319, 319, 319, 319, 319, 319, 319, 319, 318, 319, 318, 317, 318, 318, 318, 318, 318, 318, 318, 326, 296, 436, 1702, 3156, 4565, 5983, 7404, 8820, 10238, 11658, 13072, 14489, 15907, 17320, 18737, 20152, 21565, 22979, 24393, 25803, 27216, 28628, 30002, 31564, 31860, 30323, 28912, 27483, 26054, 24620, 23189, 21759, 20325, 18895, 17464, 16031, 14601, 13172, 11740, 10312, 8806, 7818, 4249, -413, 99, -5, -10, -16, -20, -25, -29, -33, -36, -40, -42, -44, -47, -49, -50, -53, -54, -55, -57, -58, -59, -60, -60, -62, -63, -63, -64, -63, -65, -66, -65, -66, -67, -66, -67, -66, -67, -67, -68, -67, -67, -67, -67, -67, -67, -67, -67, -67, -68, -68, -67, -69, -70, -69, -69, -69, -69, -69, -69, -69, -69, -69, -69, -69, -69, -69, -69, -69, -69, -69, -69, -69, -69, -69, -69, -69, -69, -69, -69, -69, -69, -69, -69, -69, -69, -69, -69, -69, -70, -69, -68, -67, -68, -67, -67, -67, -67, -67, -67, -67, -67, -67, -67, -67, -67, -67, -85, -8, -577, -2082, -3522, -4970, -6418, -7870, -9318, -10765, -12216, -13662, -15108, -16558, -18003, -19448, -20895, -22338, -23782, -25227, -26667, -28110, -29546, -30988, -32434, -31750, -30157, -28724, -27261, -25802, -24337, -22874, -21414, -19949, -18487, -17027, -15562, -14101, -12642, -11180, -9719, -8261, -6802, -5349, -3865};