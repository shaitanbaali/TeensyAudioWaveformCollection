/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0592 256 samples */
 
const int16_t AKWF_0592_256_DATA [256] = 
{192, 549, 898, 1250, 1599, 1950, 2301, 2650, 2999, 3349, 3698, 4047, 4397, 4745, 5094, 5443, 5790, 6139, 6487, 6834, 7182, 7529, 7876, 8223, 8570, 8916, 9263, 9609, 9955, 10301, 10646, 10992, 11344, 11613, 12391, 10968, 7715, 6585, 6785, 6795, 6839, 6884, 6927, 6972, 7016, 7061, 7105, 7149, 7194, 7238, 7283, 7327, 7372, 7416, 7461, 7505, 7550, 7594, 7639, 7683, 7728, 7772, 7817, 7861, 7906, 7950, 7994, 8039, 8083, 8127, 8172, 8216, 8260, 8305, 8349, 8393, 8437, 8481, 8526, 8570, 8614, 8658, 8702, 8746, 8790, 8834, 8878, 8922, 8967, 9010, 9054, 9098, 9141, 9185, 9230, 9273, 9316, 9360, 9404, 9448, 9491, 9535, 9578, 9623, 9666, 9710, 9753, 9796, 9840, 9883, 9926, 9970, 10014, 10057, 10101, 10143, 10186, 10230, 10273, 10316, 10360, 10402, 10445, 10489, 10532, 10575, 10618, 10661, 10704, 10747, 10790, 10833, 10876, 10918, 10962, 11004, 11047, 11089, 11132, 11175, 11218, 11261, 11303, 11346, 11388, 11431, 11473, 11516, 11558, 11601, 11644, 11686, 11728, 11770, 11813, 11855, 11897, 11940, 11982, 12024, 12060, 12095, 12121, 9876, 4384, -7408, -20238, -31698, -31986, -30749, -30576, -30206, -29853, -29500, -29146, -28789, -28434, -28077, -27719, -27362, -27003, -26643, -26284, -25923, -25563, -25203, -24842, -24481, -24120, -23759, -23398, -23036, -22674, -22313, -21952, -21589, -21228, -20866, -20505, -20144, -19782, -19421, -19060, -18698, -18337, -17976, -17615, -17254, -16894, -16534, -16173, -15813, -15452, -15092, -14733, -14373, -14014, -13655, -13296, -12937, -12578, -12219, -11860, -11503, -11145, -10787, -10430, -10072, -9715, -9358, -9001, -8645, -8289, -7932, -7576, -7221, -6865, -6510, -6155, -5800, -5446, -5091, -4737, -4384, -4030, -3676, -3324, -2971, -2618, -2267, -1914, -1562, -1210, -859, -509, -152};