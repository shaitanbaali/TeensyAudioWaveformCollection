/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0515 256 samples */
 
const int16_t AKWF_0515_256_DATA [256] = 
{2640, 9768, 14575, 16315, 15512, 12895, 9498, 6232, 3672, 2017, 1134, 1006, 565, -1037, -3504, -4683, -3483, -1612, -3460, -8138, -12408, -14811, -15390, -13611, -10233, -6228, -2273, 1146, 3870, 5979, 7644, 9002, 10107, 10674, 8430, 4018, -542, 13, 3039, 7150, 11031, 13617, 14566, 14112, 12826, 11350, 10177, 9396, 8620, 7933, 7398, 6195, 4759, 3355, 2310, 1912, 2314, 3486, 5243, 7298, 9329, 11048, 12207, 12659, 12625, 12378, 11991, 11511, 10988, 10462, 9969, 9553, 9258, 9124, 9185, 9465, 9861, 10768, 12164, 13071, 13746, 14334, 13468, 12827, 13309, 13011, 12201, 11075, 10009, 9221, 8571, 7907, 7242, 6661, 6230, 5918, 5797, 5998, 5887, 5907, 6065, 6320, 6617, 6930, 7265, 7629, 7996, 8416, 9110, 9372, 9517, 9899, 10812, 11961, 13182, 13035, 13514, 14481, 15077, 15290, 15442, 15511, 15455, 15672, 15603, 15176, 14457, 13628, 15831, 21140, 25532, 27457, 26667, 23893, 19790, 14970, 10509, 6944, 4529, 2545, 1324, 795, 194, 92, 879, 466, -8328, -18155, -26914, -31607, -29732, -28508, -24764, -21294, -21179, -17961, -19679, -18774, -16381, -10184, -7987, -6789, -10319, -16265, -20064, -19347, -14779, -9923, -2349, 225, -626, -4834, -6157, -8430, -10935, -11247, -8081, -9299, -9702, -10646, -16487, -18331, -18893, -14704, -14102, -12956, -14844, -15227, -13052, -11967, -11420, -6549, -5974, -7218, -7756, -12572, -16432, -17526, -17635, -14234, -15341, -16018, -16443, -16577, -16418, -16001, -15380, -14682, -13762, -12534, -13160, -13460, -12574, -12470, -12889, -13635, -14330, -14753, -15061, -15438, -15847, -15417, -15446, -15596, -15543, -15407, -15189, -14858, -14421, -13923, -13419, -12943, -12491, -12056, -11652, -11292, -11028, -10468, -10117, -10502, -8152, -4277, -4721, -4633, -4642, -4656, -4667, -4659, -4626, -4576, -4485, -4324, -4144, -4046, -4311, -2956};