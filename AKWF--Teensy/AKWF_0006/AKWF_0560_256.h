/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0560 256 samples */
 
const int16_t AKWF_0560_256_DATA [256] = 
{115, 284, 449, 613, 776, 939, 1100, 1259, 1417, 1574, 1730, 1884, 2037, 2187, 2337, 2485, 2631, 2775, 2918, 3058, 3197, 3334, 3469, 3603, 3733, 3862, 3989, 4114, 4236, 4357, 4475, 4590, 4704, 4816, 4924, 5029, 5134, 5235, 5334, 5431, 5525, 5617, 5705, 5791, 5875, 5956, 6035, 6111, 6184, 6255, 6323, 6388, 6450, 6511, 6567, 6623, 6675, 6725, 6772, 6816, 6858, 6896, 6933, 6967, 6998, 7027, 7054, 7077, 7098, 7116, 7133, 7147, 7158, 7167, 7174, 7178, 7180, 7180, 7177, 7173, 7165, 7156, 7145, 7132, 7116, 7099, 7080, 7058, 7035, 7010, 6982, 6954, 6923, 6891, 6856, 6821, 6783, 6744, 6704, 6662, 6619, 6574, 6528, 6480, 6431, 6381, 6330, 6277, 6223, 6169, 6113, 6057, 5999, 5941, 5881, 5821, 5760, 5698, 5635, 5572, 5508, 5444, 5379, 5313, 5247, 5180, 5114, 5047, 4978, 4911, 4843, 4774, 4706, 4637, 4569, 4500, 4431, 4362, 4293, 4224, 4155, 4087, 4018, 3950, 3882, 3814, 3725, 3625, 3618, -2369, -18667, -31979, -30315, -17352, -5844, -4474, -11330, -17820, -17313, -10207, -2146, 1586, 127, -3414, -5439, -4841, -3237, -2914, -4738, -7698, -10097, -11029, -10867, -10625, -10974, -11779, -12415, -12407, -11804, -11039, -10515, -10314, -10230, -10024, -9642, -9223, -8947, -8882, -8957, -9046, -9078, -9076, -9106, -9205, -9352, -9490, -9575, -9606, -9607, -9601, -9593, -9564, -9498, -9390, -9255, -9107, -8954, -8794, -8622, -8436, -8239, -8041, -7845, -7653, -7461, -7269, -7075, -6882, -6693, -6507, -6324, -6139, -5956, -5772, -5589, -5407, -5226, -5043, -4861, -4678, -4494, -4311, -4128, -3945, -3762, -3579, -3396, -3214, -3032, -2850, -2670, -2490, -2310, -2132, -1954, -1777, -1601, -1425, -1250, -1076, -903, -731, -560, -390, -221, -49};