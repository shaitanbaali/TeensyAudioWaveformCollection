/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0578 256 samples */
 
const int16_t AKWF_0578_256_DATA [256] = 
{803, 812, 844, 796, 702, 908, 1768, 2651, 3527, 4405, 5281, 6159, 7036, 7911, 8787, 9663, 10536, 11411, 12285, 13157, 14031, 14903, 15774, 16646, 17517, 18386, 19257, 20127, 20995, 21865, 22732, 23599, 24468, 25334, 26199, 27066, 27930, 28796, 29661, 30523, 31367, 32322, 32352, 31378, 30506, 29618, 28729, 27839, 26951, 26061, 25170, 24283, 23393, 22503, 21615, 20726, 19838, 18951, 18061, 17174, 16288, 15399, 14514, 13628, 12740, 11856, 10971, 10085, 9201, 8318, 7432, 6551, 5668, 4784, 3904, 3022, 2140, 1272, 344, -212, -187, -197, -201, -203, -206, -209, -211, -213, -215, -216, -218, -220, -220, -222, -223, -223, -224, -224, -225, -227, -226, -227, -228, -228, -227, -228, -230, -229, -229, -229, -229, -229, -229, -229, -229, -229, -229, -229, -229, -229, -229, -229, -229, -229, -229, -229, -229, -229, -229, -229, -229, -229, -229, -229, -229, -229, -229, -229, -229, -229, -230, -229, -228, -227, -228, -227, -227, -227, -227, -227, -227, -227, -227, -227, -227, -228, -227, -227, -226, -227, -226, -226, -226, -226, -226, -226, -226, -226, -226, -226, -227, -226, -225, -224, -225, -224, -224, -224, -224, -224, -224, -224, -224, -224, -225, -224, -225, -228, -209, -807, -1733, -2605, -3488, -4369, -5250, -6132, -7012, -7893, -8774, -9653, -10534, -11414, -12292, -13171, -14050, -14927, -15806, -16684, -17559, -18437, -19314, -20187, -21064, -21939, -22812, -23687, -24561, -25433, -26307, -27179, -28050, -28922, -29793, -30662, -31516, -32463, -32322, -31331, -30458, -29562, -28665, -27770, -26873, -25976, -25081, -24184, -23287, -22392, -21497, -20600, -19707, -18810, -17915, -17022, -16126, -15232, -14340, -13446, -12553, -11661, -10768, -9877, -8987, -8097, -7209, -6303};