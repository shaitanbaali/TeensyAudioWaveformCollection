/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0566 256 samples */
 
const int16_t AKWF_0566_256_DATA [256] = 
{812, 3466, 5915, 8232, 10413, 12465, 14391, 16184, 17852, 19395, 20807, 22096, 23260, 24294, 25204, 25986, 26640, 27167, 27566, 27818, 28064, 27291, 25827, 24838, 23924, 23089, 22304, 21562, 20851, 20166, 19505, 18865, 18240, 17632, 17038, 16455, 15886, 15328, 14777, 14237, 13706, 13182, 12666, 12157, 11655, 11161, 10671, 10187, 9712, 9239, 8771, 8311, 7853, 7400, 6954, 6510, 6071, 5636, 5205, 4778, 4356, 3936, 3520, 3109, 2699, 2294, 1893, 1494, 1099, 707, 318, -67, -450, -830, -1206, -1581, -1951, -2319, -2686, -3049, -3408, -3766, -4121, -4472, -4822, -5170, -5514, -5855, -6195, -6531, -6867, -7198, -7528, -7856, -8180, -8503, -8823, -9140, -9455, -9769, -10080, -10387, -10694, -10998, -11300, -11599, -11896, -12191, -12483, -12774, -13062, -13348, -13632, -13914, -14194, -14471, -14746, -15019, -15290, -15558, -15826, -16089, -16352, -16613, -16870, -17127, -17380, -17632, -17882, -18128, -18373, -18617, -18858, -19098, -19334, -19569, -19803, -20033, -20262, -20489, -20713, -20935, -21156, -21374, -21590, -21804, -22016, -22227, -22434, -22640, -22844, -23046, -23246, -23442, -23639, -23832, -24022, -24212, -24400, -24584, -24767, -24949, -25128, -25305, -25480, -25652, -25824, -25991, -26159, -26324, -26485, -26647, -26805, -26960, -27116, -27267, -27416, -27565, -27711, -27855, -27996, -28137, -28274, -28410, -28544, -28675, -28805, -28932, -29057, -29181, -29302, -29421, -29538, -29653, -29765, -29877, -29985, -30092, -30197, -30299, -30399, -30498, -30593, -30688, -30781, -30870, -30958, -31044, -31127, -31209, -31289, -31366, -31442, -31515, -31587, -31655, -31723, -31788, -31851, -31912, -31971, -32027, -32082, -32135, -32186, -32233, -32279, -32323, -32366, -32405, -32443, -32479, -32512, -32544, -32574, -32601, -32627, -32649, -32671, -32691, -32707, -32723, -32735, -32745, -32755, -32760, -32672, -33130, -29532, -23141, -18828, -14870, -11279, -7950, -4845, -1874};