/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0524 256 samples */
 
const int16_t AKWF_0524_256_DATA [256] = 
{1270, 1270, 1270, 1270, 1270, 1270, 1542, 84, 8306, 17589, 16107, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16399, 16313, 17313, 17725, 17636, 17630, 17748, 16871, 16292, 16405, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16151, 17425, 6270, 266, 1493, 1270, 1270, 1270, 1259, 1316, 1076, -15, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -3, -143, 680, -11624, -15892, -14946, -15114, -15114, -15114, -15114, -15114, -15114, -15114, -15114, -15114, -15114, -15114, -15114, -15114, -15114, -15114, -15114, -15114, -15114, -15114, -15114, -15114, -15114, -15114, -15114, -15114, -15114, -15114, -15114, -15114, -15114, -15114, -15114, -15129, -15049, -15408, -16442, -16373, -16384, -16384, -16637, -15271, -22389, -32658, -31235, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31521, -31400, -32072, -32868, -32744, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32744, -32868, -32054, -31401, -31521, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31498, -31224, -32693, -24254, -15179, -16662, -16384, -16384, -16364, -16475, -15551, -15028, -15134, -15114, -15105, -15039, -15530, -2793, 651, -141, 0, 0, 0, 0};