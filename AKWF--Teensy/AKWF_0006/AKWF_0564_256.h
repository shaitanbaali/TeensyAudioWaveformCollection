/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0564 256 samples */
 
const int16_t AKWF_0564_256_DATA [256] = 
{178, 437, 690, 943, 1195, 1448, 1701, 1951, 2202, 2453, 2703, 2953, 3203, 3450, 3699, 3948, 4194, 4441, 4688, 4933, 5179, 5425, 5669, 5913, 6157, 6400, 6643, 6885, 7126, 7368, 7609, 7849, 8089, 8328, 8567, 8807, 9044, 9282, 9519, 9756, 9992, 10228, 10463, 10698, 10932, 11166, 11401, 11631, 11887, 12267, 12661, 13048, 13434, 13817, 14197, 14576, 14952, 15325, 15696, 16064, 16429, 16793, 17154, 17512, 17869, 18222, 18574, 18923, 19268, 19612, 19955, 20293, 20630, 20964, 21295, 21624, 21951, 22275, 22597, 22917, 23234, 23548, 23860, 24170, 24477, 24782, 25084, 25383, 25681, 25976, 26269, 26559, 26846, 27131, 27414, 27694, 27972, 28247, 28520, 28791, 29058, 29323, 29588, 29847, 30106, 30362, 30615, 30865, 31120, 31291, 31826, 31853, 24488, 21786, 20909, 19627, 18408, 17188, 15971, 14751, 13531, 12314, 11095, 9875, 8659, 7438, 6219, 5002, 3781, 2563, 1346, 125, -1091, -2310, -3531, -4747, -5967, -7187, -8404, -9623, -10843, -12060, -13280, -14499, -15716, -16936, -18156, -19373, -20592, -21811, -23029, -24248, -25467, -26687, -27880, -29514, -29639, -29219, -28921, -28608, -28293, -27980, -27667, -27354, -27043, -26731, -26420, -26110, -25800, -25490, -25182, -24874, -24565, -24259, -23953, -23646, -23340, -23035, -22730, -22426, -22123, -21819, -21519, -21216, -20914, -20614, -20313, -20013, -19714, -19415, -19116, -18818, -18522, -18225, -17929, -17632, -17338, -17043, -16748, -16455, -16163, -15870, -15577, -15286, -14995, -14705, -14415, -14125, -13837, -13548, -13260, -12973, -12686, -12400, -12115, -11829, -11544, -11260, -10976, -10693, -10411, -10128, -9846, -9565, -9286, -9005, -8725, -8447, -8169, -7890, -7613, -7336, -7060, -6784, -6510, -6234, -5960, -5686, -5412, -5140, -4868, -4597, -4325, -4055, -3784, -3514, -3246, -2977, -2710, -2443, -2175, -1908, -1643, -1378, -1113, -846};