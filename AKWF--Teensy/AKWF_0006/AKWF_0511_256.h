/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0511 256 samples */
 
const int16_t AKWF_0511_256_DATA [256] = 
{288, 709, 1120, 1533, 1946, 2359, 2772, 3186, 3599, 4012, 4424, 4837, 5251, 5663, 6076, 6490, 6903, 7316, 7730, 8142, 8556, 8969, 9382, 9795, 10209, 10621, 11034, 11447, 11860, 12274, 12687, 13099, 13512, 13925, 14338, 14752, 15165, 15578, 15991, 16402, 16609, 18213, 2422, -3125, -1403, -1224, -810, -396, 15, 428, 842, 1254, 1668, 2082, 2494, 2907, 3320, 3732, 4147, 4559, 4972, 5386, 5798, 6211, 6625, 7037, 7450, 7864, 8277, 8690, 9104, 9516, 9930, 10343, 10756, 11169, 11582, 11995, 12408, 12822, 13233, 13648, 14061, 14473, 14886, 15300, 15712, 16126, 16539, 16952, 17366, 17778, 18191, 18605, 19018, 19431, 19844, 20256, 20669, 21083, 21495, 21909, 22322, 22735, 23148, 23562, 23974, 24388, 24801, 25214, 25627, 26041, 26453, 26866, 27280, 27692, 28105, 28519, 28931, 29345, 29757, 30170, 30584, 30997, 31410, 30687, 37215, 4832, -37615, -30884, -31647, -31234, -30821, -30408, -29994, -29581, -29169, -28756, -28342, -27930, -27516, -27104, -26690, -26277, -25865, -25451, -25038, -24625, -24212, -23798, -23386, -22972, -22559, -22146, -21733, -21319, -20907, -20493, -20081, -19668, -19255, -18842, -18429, -18015, -17603, -17190, -16776, -16363, -15950, -15536, -15124, -14711, -14298, -13885, -13472, -13058, -12646, -12232, -11819, -11407, -10994, -10580, -10168, -9754, -9341, -8928, -8514, -8102, -7689, -7275, -6862, -6449, -6035, -5623, -5211, -4796, -4384, -3971, -3557, -3145, -2732, -2318, -1906, -1493, -1079, -667, -253, 160, 572, 986, 1262, 2421, -215, -17341, -17124, -16603, -16228, -15816, -15402, -14989, -14576, -14162, -13750, -13337, -12924, -12511, -12098, -11685, -11271, -10858, -10445, -10033, -9620, -9206, -8793, -8380, -7967, -7554, -7140, -6727, -6315, -5901, -5488, -5075, -4662, -4249, -3837, -3423, -3010, -2597, -2184, -1770, -1358, -945, -533, -113};