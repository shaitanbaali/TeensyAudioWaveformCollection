/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0549 256 samples */
 
const int16_t AKWF_0549_256_DATA [256] = 
{3867, 9911, 15537, 20648, 25184, 28519, 30813, 31720, 31340, 29809, 27166, 23623, 18937, 13499, 7329, 1233, -4861, -11026, -16661, -21412, -25712, -29409, -31559, -32629, -32298, -30719, -27975, -23859, -20398, -15501, -8288, -2164, 3941, 10070, 15703, 20829, 25095, 28501, 30396, 31331, 31257, 29764, 27230, 23568, 18977, 13298, 7360, 1223, -4875, -10882, -16606, -21625, -25890, -29004, -31230, -32350, -32155, -30339, -27793, -24467, -19548, -14096, -8492, -2328, 4240, 10082, 15615, 21019, 24333, 27812, 30858, 31715, 31339, 29809, 27166, 23623, 18937, 13499, 7329, 1233, -4861, -11026, -16661, -21412, -25712, -29409, -31559, -32629, -32298, -30719, -27941, -24029, -19414, -14309, -8502, -1916, 4348, 10337, 15697, 20642, 25043, 28431, 30843, 31787, 31638, 30079, 27214, 23547, 20165, 13610, 7317, 1234, -4875, -10882, -16606, -21625, -25890, -29004, -31230, -32350, -32155, -30339, -27793, -24467, -19548, -14096, -8492, -2328, 4240, 10083, 15620, 20982, 25250, 28196, 30421, 31767, 31233, 29697, 27116, 23473, 18931, 13533, 7693, 1611, -4502, -10570, -16552, -21125, -24626, -29348, -31577, -32622, -32298, -30719, -27941, -24029, -19414, -14309, -8502, -1916, 4348, 10337, 15697, 20642, 25043, 28431, 30843, 31787, 31638, 30066, 27287, 23253, 18751, 13724, 7758, 1453, -5100, -11123, -16678, -21676, -25990, -29123, -31285, -32453, -32184, -30838, -27890, -25512, -20254, -14065, -8495, -2330, 4240, 10083, 15620, 20982, 25250, 28196, 30421, 31767, 31233, 29697, 27116, 23473, 18931, 13533, 7693, 1611, -4502, -10595, -16432, -21796, -25917, -29146, -31314, -32134, -31851, -30464, -28030, -24164, -19535, -14204, -8307, -2159, 3944, 9935, 15330, 18895, 24513, 28497, 30827, 31787, 31638, 30066, 27287, 23253, 18751, 13724, 7758, 1453, -5100, -11123, -16678, -21676, -25990, -29123, -31285, -32453, -32184, -30819, -27988, -24183, -19348, -13991, -8241, -2111};