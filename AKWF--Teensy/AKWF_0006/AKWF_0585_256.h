/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0585 256 samples */
 
const int16_t AKWF_0585_256_DATA [256] = 
{891, 3188, 5298, 7283, 9159, 10961, 12715, 14427, 16094, 17715, 19271, 20707, 21933, 22907, 23635, 24124, 24380, 24434, 24327, 24115, 23849, 23576, 23313, 23040, 22689, 22125, 21198, 19852, 18113, 16022, 13661, 11129, 8519, 5955, 3537, 1345, -553, -2141, -3427, -4433, -5199, -5754, -6128, -6346, -6411, -6312, -6043, -5611, -5019, -4283, -3437, -2526, -1604, -732, 43, 702, 1244, 1666, 2040, 2481, 3075, 3867, 4843, 5960, 7179, 8417, 9595, 10626, 11432, 11954, 12178, 12118, 11813, 11285, 10569, 9737, 8861, 7952, 6985, 5941, 4811, 3571, 2216, 741, -847, -2527, -4228, -5985, -9419, -13224, -16529, -19295, -21294, -22371, -22466, -21636, -20043, -17882, -15361, -12683, -10063, -7700, -5800, -4560, -4123, -4559, -5878, -8023, -10832, -14075, -17538, -20996, -24232, -27094, -29447, -31206, -32329, -32765, -32461, -31349, -29359, -26478, -22675, -18029, -12666, -6994, -3810, -1485, 925, 3177, 5294, 7282, 9157, 10960, 12715, 14426, 16093, 17714, 19271, 20707, 21933, 22906, 23635, 24124, 24379, 24434, 24327, 24113, 23848, 23575, 23311, 23040, 22689, 22125, 21197, 19851, 18113, 16021, 13661, 11129, 8518, 5954, 3536, 1345, -553, -2142, -3428, -4434, -5199, -5754, -6128, -6348, -6412, -6312, -6045, -5611, -5019, -4284, -3437, -2527, -1605, -732, 43, 701, 1244, 1665, 2040, 2481, 3074, 3867, 4842, 5959, 7178, 8416, 9595, 10626, 11430, 11954, 12178, 12117, 11812, 11284, 10569, 9737, 8860, 7952, 6985, 5940, 4810, 3570, 2216, 741, -847, -2528, -4228, -5986, -9419, -13224, -16531, -19297, -21294, -22372, -22466, -21638, -20044, -17882, -15361, -12684, -10065, -7700, -5801, -4561, -4124, -4560, -5878, -8024, -10833, -14075, -17538, -20996, -24232, -27094, -29447, -31206, -32329, -32765, -32463, -31349, -29360, -26479, -22676, -18029, -12667, -6999, -3821, -1454};