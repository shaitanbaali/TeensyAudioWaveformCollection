/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0527 256 samples */
 
const int16_t AKWF_0527_256_DATA [256] = 
{851, 2178, 5066, 4784, 4835, 4835, 4835, 4835, 4835, 4835, 4835, 4835, 4835, 4835, 4835, 4835, 4942, 4337, 7088, 14856, 14979, 15673, 15569, 15589, 15589, 15589, 15589, 15589, 15589, 15589, 15589, 15589, 15589, 15589, 15589, 15570, 15673, 15100, 14421, 14527, 14507, 14507, 14507, 14507, 14507, 14507, 14507, 14507, 14507, 14507, 14507, 14507, 14586, 14157, 16451, 19314, 23297, 25644, 25176, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25261, 25167, 25667, 21419, 18811, 15045, 14391, 14534, 14507, 14507, 14507, 14507, 14507, 14507, 14507, 14507, 14507, 14507, 14507, 14495, 14510, 14323, 8222, 953, -19973, -19217, -19375, -19137, -20212, -27374, -29668, -33087, -32691, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32749, -32842, -32349, -29798, -25896, -18711, -19487, -19343, -19343, -19343, -19343, -19343, -19343, -19343, -19343, -19343, -19343, -19343, -19343, -19343, -19343, -19343, -19343, -19343, -19343, -19343, -19343, -19343, -19343, -19343, -19343, -19343, -19343, -19343, -19343, -19343, -19343, -19343, -19343, -19343, -19298, -19526, -15779, -13655, -8759, -8549, -8603, -8588, -8588, -8588, -8588, -8588, -8588, -8588, -8588, -8588, -8588, -8588, -8588, -8588, -8588};