/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0551 256 samples */
 
const int16_t AKWF_0551_256_DATA [256] = 
{8416, 21749, 28482, 27184, 20407, 22004, 27098, 26637, 25718, 28822, 31758, 31421, 30943, 31833, 31569, 29612, 27953, 26962, 25528, 23891, 23077, 22982, 23021, 23365, 24297, 25469, 26504, 27429, 28255, 28750, 28803, 28532, 28023, 27288, 26425, 25613, 24964, 24520, 24346, 24486, 24906, 25537, 26304, 27128, 27907, 28553, 29012, 29255, 29276, 29100, 28783, 28393, 28000, 27674, 27476, 27442, 27590, 27907, 28367, 28922, 29512, 30083, 30581, 30964, 31208, 31308, 31279, 31147, 30954, 30745, 30563, 30448, 30426, 30510, 30695, 30970, 31306, 31667, 32018, 32326, 32563, 32713, 32768, 32736, 32632, 32480, 32310, 32146, 32015, 31936, 31918, 31963, 32061, 32200, 32357, 32511, 32641, 32729, 32762, 32738, 32655, 32525, 32360, 32180, 32000, 31837, 31705, 31610, 31554, 31536, 31544, 31568, 31594, 31610, 31603, 31564, 31492, 31386, 31250, 31094, 30927, 30760, 30605, 30469, 30359, 29973, 31268, 24579, -8346, -21817, -28405, -27184, -20407, -22004, -27098, -26637, -25718, -28822, -31758, -31421, -30943, -31833, -31569, -29612, -27953, -26962, -25528, -23891, -23077, -22982, -23021, -23366, -24297, -25470, -26504, -27429, -28255, -28751, -28803, -28532, -28024, -27288, -26425, -25614, -24964, -24520, -24347, -24486, -24906, -25537, -26304, -27129, -27907, -28553, -29012, -29255, -29276, -29100, -28783, -28393, -28000, -27674, -27476, -27443, -27590, -27907, -28367, -28922, -29512, -30083, -30581, -30964, -31208, -31308, -31279, -31148, -30954, -30745, -30563, -30448, -30426, -30510, -30695, -30970, -31306, -31667, -32018, -32326, -32563, -32712, -32768, -32736, -32632, -32480, -32309, -32145, -32015, -31936, -31918, -31963, -32061, -32199, -32357, -32511, -32641, -32729, -32762, -32736, -32654, -32524, -32360, -32180, -32000, -31837, -31705, -31610, -31555, -31536, -31544, -31568, -31594, -31609, -31602, -31564, -31492, -31386, -31250, -31094, -30927, -30760, -30605, -30469, -30359, -30050, -31205, -24667};