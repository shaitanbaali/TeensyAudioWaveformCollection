/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0504 256 samples */
 
const int16_t AKWF_0504_256_DATA [256] = 
{22938, 22944, 22950, 22954, 22958, 22961, 22962, 22964, 22965, 22965, 22963, 22962, 22960, 22959, 22956, 22953, 22950, 22947, 22943, 22939, 22935, 22931, 22927, 22922, 22918, 22913, 22907, 22902, 22898, 22892, 22887, 22881, 22876, 22870, 22865, 22859, 22853, 22848, 22843, 21893, 26992, -11106, -36235, -31348, -32253, -32254, -32253, -32254, -32253, -32250, -32248, -32245, -32241, -32237, -32233, -32227, -31217, -36594, -2025, 27142, 21883, 22868, 22870, 22871, 22871, 22871, 22871, 22870, 22868, 22867, 22864, 22861, 22858, 22855, 22852, 22848, 22844, 22840, 22835, 22831, 22826, 22821, 22816, 22811, 22806, 22801, 22796, 22791, 22785, 22779, 22774, 22768, 22763, 22757, 22751, 22745, 22739, 22734, 22728, 22722, 22716, 22710, 22705, 22699, 22693, 22687, 22681, 22675, 22668, 22662, 22656, 22650, 22645, 22639, 22633, 22627, 22620, 22614, 22608, 22602, 22597, 22591, 22585, 22578, 22572, 22566, 22560, 22555, 22549, 22543, 22535, 22530, 22524, 22518, 22512, 22506, 22500, 22493, 22488, 22482, 22476, 22470, 22464, 22458, 22451, 22446, 22440, 22434, 22428, 22422, 22416, 22409, 22403, 22397, 22391, 22386, 22380, 22374, 22368, 22362, 22355, 22349, 22343, 22337, 22331, 21534, 25884, 4808, -36432, -31944, -32765, -32767, -32767, -32767, -32766, -32764, -32762, -32759, -32755, -32751, -32747, -32742, -32737, -32732, -32726, -32719, -32713, -32707, -32700, -32694, -32686, -32679, -32672, -32664, -32656, -32648, -32640, -32632, -32624, -32617, -32609, -32601, -32593, -32584, -32575, -32568, -32560, -32551, -32542, -32535, -32525, -32517, -32509, -32500, -32492, -32483, -32474, -32466, -32457, -32449, -32440, -32431, -32422, -32414, -32405, -32396, -32388, -32379, -32371, -32362, -32354, -32345, -32336, -32328, -32319, -32310, -32301, -32293, -32284, -32276, -32267, -32259, -32249, -32241, -32232, -32224, -32215, -32207, -32198, -32189, -32181, -32172, -32164, -32154, -32146, -32138};