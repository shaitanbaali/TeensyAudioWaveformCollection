/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0545 256 samples */
 
const int16_t AKWF_0545_256_DATA [256] = 
{20370, 29933, 24942, 20305, 21431, 19800, 15621, 12290, 20727, 19519, 16074, 12509, 12523, 11311, 8194, 2854, 18268, 20361, 15319, 12828, 13713, 10657, 8023, 3372, 10521, 11958, 7650, 3630, 5613, 2187, -1352, -4666, 9217, 11864, 8191, 3311, 4434, 2801, -1376, -4706, 3730, 2521, -923, -4487, -4473, -5685, -8802, -14141, 1271, 3362, -1678, -4168, -3284, -6339, -8973, -13624, -6475, -5038, -9344, -13366, -11385, -14776, -18214, -22378, 11924, 21582, 16416, 11806, 12932, 11301, 7122, 3791, 12228, 11020, 7575, 4011, 4025, 2811, -303, -5643, 9770, 11861, 6820, 4330, 5215, 2158, -476, -5126, 2023, 3460, -847, -4867, -2885, -6286, -9770, -13600, 13818, 21172, 16508, 11807, 12932, 11300, 7122, 3791, 12228, 11020, 7575, 4010, 4024, 2812, -303, -5643, 9770, 11861, 6820, 4330, 5214, 2158, -475, -5126, 2023, 3460, -847, -4868, -2886, -6295, -9725, -13791, 13973, 21191, 16507, 11806, 12932, 11301, 7123, 3791, 12228, 11020, 7575, 4011, 4025, 2811, -303, -5643, 9770, 11862, 6820, 4330, 5215, 2159, -475, -5125, 2023, 3460, -848, -4868, -2884, -6310, -9850, -13164, 719, 3365, -307, -5187, -4064, -5696, -9874, -13205, -4768, -5977, -9421, -12985, -12971, -14184, -17300, -22640, -7227, -5135, -10176, -12666, -11781, -14838, -17472, -22123, -14973, -13536, -17843, -21865, -19883, -23274, -26713, -30875, 3427, 13083, 7918, 3307, 4433, 2803, -1375, -4707, 3730, 2521, -923, -4487, -4472, -5686, -8801, -14142, 1271, 3363, -1678, -4168, -3282, -6339, -8974, -13624, -6474, -5038, -9345, -13366, -11384, -14785, -18269, -22098, 5320, 12673, 8009, 3308, 4433, 2802, -1375, -4707, 3729, 2521, -923, -4486, -4473, -5687, -8801, -14142, 1271, 3363, -1678, -4168, -3283, -6339, -8974, -13624, -6475, -5038, -9344, -13366, -11384, -14877, -18225, -22013};