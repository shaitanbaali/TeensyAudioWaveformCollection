/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0600 256 samples */
 
const int16_t AKWF_0600_256_DATA [256] = 
{400, 1186, 1956, 2727, 3499, 4270, 5042, 5811, 6582, 7359, 8086, 9024, 10496, 10510, 10501, 10502, 10500, 10497, 10495, 10492, 10488, 10484, 10480, 10476, 10473, 10469, 10465, 10460, 10456, 10450, 10445, 10441, 10437, 10432, 10425, 10421, 10417, 10410, 10406, 10401, 10395, 10390, 10385, 10380, 10374, 10369, 10364, 10358, 10353, 10348, 10342, 10336, 10331, 10326, 10320, 10315, 10310, 10304, 10298, 10294, 10288, 10282, 10277, 10271, 10265, 10260, 10255, 10249, 10244, 10238, 10233, 10227, 10223, 10217, 10211, 10205, 10200, 10194, 10189, 10184, 10178, 10173, 10167, 10162, 10156, 10151, 10145, 10140, 10134, 10130, 10124, 10118, 10113, 10107, 10102, 10097, 10092, 10085, 10080, 10075, 10070, 10063, 10059, 10053, 10048, 10042, 10038, 10031, 10026, 10021, 10016, 10009, 10005, 9999, 9994, 9988, 9984, 9977, 9972, 9967, 9962, 9956, 9951, 9945, 9940, 9934, 9930, 9923, 9919, 9913, 9908, 9902, 9897, 9891, 9886, 9881, 9876, 9870, 9865, 9860, 9854, 9849, 9843, 9839, 9832, 9828, 9822, 9797, 9895, 9020, 8014, 7434, 6769, 6119, 5465, 4814, 4163, 3511, 2861, 2210, 1559, 910, 260, -390, -1039, -1688, -2338, -2985, -3634, -4283, -4929, -5577, -6225, -6871, -7517, -8164, -8809, -9455, -10100, -10744, -11390, -12035, -12678, -13322, -13964, -14607, -15250, -15892, -16534, -17175, -17816, -18457, -19098, -19738, -20377, -21018, -21655, -22294, -22933, -23571, -24209, -24847, -25482, -26119, -26757, -27391, -28028, -28665, -29298, -29932, -30568, -31200, -31819, -32522, -32413, -31555, -30787, -30005, -29219, -28435, -27652, -26866, -26082, -25299, -24513, -23730, -22948, -22163, -21381, -20598, -19814, -19033, -18250, -17466, -16687, -15907, -15123, -14344, -13564, -12784, -12005, -11225, -10446, -9669, -8890, -8111, -7335, -6558, -5781, -5005, -4229, -3453, -2679, -1905, -1134, -346};