/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0593 256 samples */
 
const int16_t AKWF_0593_256_DATA [256] = 
{178, 179, 180, 179, 180, 181, 180, 181, 181, 180, 181, 183, 182, 183, 183, 183, 183, 183, 183, 183, 183, 183, 183, 183, 183, 183, 183, 183, 182, 183, 182, 181, 179, -21, 198, 78, 929, 1142, 33, 272, -149, -202, 252, 165, 180, 180, 180, 180, 180, 180, 180, 180, 179, 180, 179, 178, 179, 179, 179, 179, 179, -139, 1620, -8625, -3088, 992, 81, 179, 180, 179, 180, 181, 181, 181, 181, 181, 181, 181, 181, 181, 181, 181, 181, 181, 181, 181, 181, 181, 166, 263, -293, -221, 263, 165, 181, 181, 198, 128, 442, 2520, 1082, -37, 284, -422, -2509, -1173, 438, 125, 180, 180, 180, 180, 180, 180, 179, 180, 179, 179, 179, 179, 179, 179, 179, 179, 179, -258, 2157, -11907, -4305, 1295, 45, 180, 180, 181, 182, 183, 182, 183, 182, 183, 183, 184, 184, 184, 184, 184, 184, 184, 184, 184, 184, 184, 184, 184, 184, 184, 184, 184, 184, 184, 182, -19, 200, 80, 930, 1143, 35, 274, -147, -200, 254, 169, 181, 180, 181, 181, 181, 181, 181, 181, 181, 181, 180, 181, 180, 179, 180, 180, 180, -139, 1622, -8632, -3090, 994, 82, 181, 180, 181, 183, 182, 183, 183, 183, 183, 183, 183, 183, 183, 183, 183, 183, 183, 183, 183, 183, 183, 183, 183, 183, 183, 182, 176, 217, -459, 56, 223, 93, 1862, 2490, -26, 244, 94, -1441, -750, 358, 143, 180, 180, 180, 180, 180, 180, 180, 180, 180, 180, 179, 180, 179, 178, 179, 179, 179, -316, 2346, -11934};