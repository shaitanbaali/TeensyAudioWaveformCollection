/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0557 256 samples */
 
const int16_t AKWF_0557_256_DATA [256] = 
{56, 144, 236, 331, 428, 529, 635, 744, 856, 972, 1090, 1213, 1340, 1468, 1601, 1738, 1877, 2019, 2166, 2314, 2467, 2623, 2781, 2943, 3108, 3276, 3446, 3619, 3795, 3975, 4157, 4342, 4529, 4719, 4911, 5107, 5303, 5502, 5706, 5909, 6116, 6324, 6535, 6748, 6963, 7179, 7398, 7617, 7839, 8062, 8287, 8513, 8741, 8970, 9201, 9433, 9665, 9899, 10134, 10371, 10608, 10845, 11084, 11322, 11563, 11803, 12043, 12286, 12527, 12770, 13012, 13255, 13498, 13741, 13983, 14226, 14469, 14712, 14955, 15197, 15439, 15681, 15921, 16161, 16402, 16642, 16880, 17120, 17357, 17594, 17830, 18066, 18300, 18533, 18765, 18996, 19227, 19456, 19125, 22389, -6466, -32144, -32462, -32555, -31962, -31115, -30183, -29218, -28243, -27273, -26310, -25360, -24430, -23517, -22624, -21757, -20911, -20089, -19291, -18517, -17767, -17042, -16338, -15658, -15000, -14361, -13746, -13150, -12572, -12015, -11476, -10954, -10450, -9963, -9491, -9035, -8595, -8170, -7760, -7363, -6980, -6613, -6257, -5913, -5584, -5267, -4961, -4668, -4386, -4115, -3856, -3608, -3371, -3145, -2928, -2721, -2525, -2337, -2159, -1991, -1832, -1680, -1539, -1404, -1278, -1160, -1049, -947, -850, -763, -680, -603, -535, -472, -415, -364, -318, -277, -241, -211, -185, -165, -148, -134, -125, -120, -118, -120, -126, -133, -144, -157, -172, -189, -210, -231, -254, -280, -307, -334, -363, -393, -423, -454, -486, -517, -550, -581, -613, -645, -676, -706, -736, -765, -794, -822, -847, -872, -896, -917, -938, -957, -973, -988, -1001, -1012, -1020, -1027, -1031, -1033, -1032, -1027, -1023, -1013, -1002, -987, -970, -949, -926, -900, -870, -837, -802, -761, -719, -674, -624, -571, -516, -456, -393, -327, -257, -184, -107, -24};