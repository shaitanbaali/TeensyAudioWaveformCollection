/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0558 256 samples */
 
const int16_t AKWF_0558_256_DATA [256] = 
{29, 90, 149, 210, 271, 332, 394, 457, 519, 582, 646, 710, 776, 841, 907, 973, 1039, 1106, 1174, 1242, 1310, 1379, 1448, 1519, 1589, 1659, 1730, 1802, 1874, 1946, 2018, 2091, 2165, 2239, 2314, 2388, 2463, 2539, 2615, 2691, 2767, 2844, 2923, 3001, 3078, 3157, 3236, 3315, 3394, 3475, 3555, 3636, 3717, 3798, 3880, 3962, 4044, 4128, 4211, 4294, 4378, 4463, 4547, 4632, 4717, 4803, 4889, 4975, 5061, 5148, 5236, 5322, 5411, 5499, 5587, 5676, 5764, 5853, 5944, 6033, 6123, 6214, 6305, 6397, 6487, 6579, 6671, 6763, 6855, 6948, 7041, 7135, 7228, 7322, 7416, 7510, 7605, 7699, 7794, 7890, 7984, 7622, 10277, -15748, -34530, -30033, -26088, -22161, -18604, -15506, -12831, -10542, -8597, -6941, -5540, -4363, -3372, -2546, -1862, -1298, -838, -467, -172, 57, 230, 357, 444, 497, 522, 522, 503, 468, 419, 359, 290, 215, 133, 48, -40, -129, -221, -312, -404, -495, -585, -673, -760, -845, -928, -1008, -1087, -1163, -1237, -1307, -1375, -1442, -1505, -1566, -1623, -1680, -1733, -1783, -1832, -1879, -1922, -1963, -2002, -2039, -2073, -2106, -2136, -2164, -2191, -2215, -2238, -2257, -2276, -2293, -2309, -2321, -2333, -2343, -2351, -2357, -2363, -2366, -2368, -2369, -2367, -2366, -2361, -2357, -2350, -2343, -2333, -2323, -2311, -2298, -2284, -2269, -2253, -2235, -2217, -2197, -2175, -2154, -2131, -2108, -2083, -2056, -2029, -2002, -1973, -1944, -1913, -1882, -1850, -1817, -1782, -1747, -1712, -1675, -1638, -1600, -1562, -1522, -1482, -1440, -1399, -1356, -1313, -1270, -1225, -1180, -1134, -1087, -1040, -992, -944, -894, -845, -794, -744, -692, -639, -587, -533, -479, -425, -370, -314, -258, -201, -144, -87, -27};