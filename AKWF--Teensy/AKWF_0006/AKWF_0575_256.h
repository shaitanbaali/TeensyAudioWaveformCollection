/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0575 256 samples */
 
const int16_t AKWF_0575_256_DATA [256] = 
{806, 806, 806, 806, 806, 806, 806, 806, 806, 806, 806, 806, 806, 806, 805, 804, 805, 805, 805, 804, 803, 803, 804, 802, 801, 802, 801, 801, 801, 801, 800, 799, 800, 799, 797, 798, 797, 796, 797, 797, 796, 795, 796, 795, 794, 795, 794, 792, 793, 792, 791, 792, 791, 790, 791, 789, 788, 789, 788, 788, 788, 787, 787, 787, 786, 785, 786, 785, 783, 784, 784, 783, 782, 783, 782, 781, 782, 780, 779, 780, 779, 778, 779, 778, 777, 778, 777, 775, 776, 775, 774, 775, 774, 773, 774, 773, 773, 773, 772, 771, 771, 770, 770, 770, 769, 769, 768, 769, 767, 766, 767, 766, 765, 766, 765, 764, 765, 764, 763, 764, 763, 761, 762, 761, 760, 761, 761, 760, 759, 760, 758, 757, 758, 757, 756, 757, 756, 755, 756, 755, 753, 754, 753, 753, 753, 752, 752, 752, 752, 751, 750, 751, 749, 748, 749, 748, 747, 748, 747, 746, 747, 746, 744, 745, 745, 744, 743, 744, 743, 742, 743, 742, 741, 742, 741, 743, 729, 992, 1431, 1842, 2251, 2698, 3015, 960, 675, 748, 734, 734, 733, 733, 732, 730, 730, 725, 737, 686, -362, -1698, -2979, -4267, -5558, -6848, -8135, -9425, -10715, -12001, -13290, -14578, -15862, -17150, -18282, -20387, -18321, 586, 859, 733, 779, 783, 786, 789, 791, 794, 796, 797, 800, 801, 802, 803, 804, 805, 805, 806, 806, 807, 806, 807, 808, 809, 809, 809, 809, 809, 809, 809, 809, 808, 806, 807, 807, 807, 807, 806, 805, 223, 3356, -13445};