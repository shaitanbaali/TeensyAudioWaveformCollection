/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0522 256 samples */
 
const int16_t AKWF_0522_256_DATA [256] = 
{701, 1811, 2910, 4020, 5136, 6257, 7382, 8505, 9629, 10749, 11860, 12967, 14063, 15144, 16213, 17265, 18296, 19307, 20296, 21257, 22193, 23099, 23972, 24814, 25620, 26388, 27120, 27811, 28460, 29069, 29633, 30151, 30625, 31053, 31434, 31767, 32053, 32290, 32480, 32621, 32715, 32762, 32762, 32715, 32623, 32486, 32306, 32084, 31820, 31517, 31177, 30799, 30387, 29941, 29466, 28959, 28427, 27870, 27288, 26687, 26068, 25432, 24783, 24121, 23449, 22772, 22088, 21401, 20714, 20028, 19343, 18667, 17995, 17333, 16682, 16043, 15416, 14807, 14211, 13634, 13077, 12537, 12018, 11521, 11045, 10591, 10159, 9749, 9363, 8998, 8656, 8336, 8037, 7758, 7501, 7263, 7043, 6841, 6656, 6486, 6331, 6188, 6058, 5939, 5827, 5724, 5627, 5534, 5444, 5356, 5268, 5179, 5087, 4991, 4888, 4778, 4661, 4534, 4396, 4245, 4081, 3904, 3711, 3503, 3279, 3037, 2776, 2499, 2201, 1886, 1552, 1197, 825, 434, 24, -404, -851, -1316, -1796, -2293, -2806, -3333, -3875, -4430, -4994, -5573, -6160, -6754, -7357, -7967, -8581, -9199, -9820, -10441, -11064, -11685, -12303, -12920, -13530, -14134, -14733, -15323, -15903, -16475, -17035, -17582, -18119, -18640, -19149, -19644, -20122, -20584, -21031, -21459, -21873, -22269, -22646, -23007, -23351, -23675, -23984, -24274, -24547, -24804, -25042, -25263, -25468, -25658, -25830, -25988, -26129, -26257, -26368, -26467, -26551, -26621, -26677, -26721, -26752, -26769, -26775, -26767, -26748, -26717, -26674, -26619, -26550, -26470, -26378, -26274, -26156, -26025, -25881, -25724, -25551, -25365, -25163, -24946, -24712, -24461, -24194, -23908, -23603, -23280, -22936, -22572, -22187, -21780, -21350, -20897, -20420, -19919, -19394, -18843, -18268, -17666, -17037, -16384, -15703, -14994, -14263, -13501, -12714, -11904, -11065, -10201, -9316, -8402, -7468, -6512, -5532, -4534, -3518, -2484, -1436, -350};