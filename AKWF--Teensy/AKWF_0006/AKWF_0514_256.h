/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0514 256 samples */
 
const int16_t AKWF_0514_256_DATA [256] = 
{6078, 6342, 6407, 6572, 6800, 7072, 7375, 7696, 8030, 8379, 8731, 8772, 8595, 8803, 8752, 8538, 8353, 8175, 8023, 7911, 7849, 7844, 7912, 8057, 8249, 8423, 8447, 8402, 8523, 8816, 9206, 9655, 10132, 10613, 11080, 11513, 11900, 12225, 12487, 12657, 12829, 13678, 13969, 14086, 14008, 13368, 11684, 12163, 11936, 11464, 10558, 9692, 9131, 8767, 8415, 7999, 7586, 7241, 6976, 6735, 6864, 6716, 6526, 6491, 6570, 6721, 6915, 7156, 7453, 7809, 8161, 8872, 9316, 9543, 9793, 10779, 11772, 13415, 13518, 13813, 14737, 15580, 15846, 16022, 16103, 16041, 16126, 16203, 15820, 14988, 14703, 22527, 26369, 22266, 18880, 17491, 16442, 15821, 14891, 14041, 13277, 12988, 12560, 12249, 12489, 12531, 12401, 12624, 12783, 1552, -17124, -24613, -29054, -24026, -21806, -18179, -15778, -17851, -18196, -21406, -24702, -24755, -21335, -18748, -19274, -24626, -32225, -32750, -23884, -14228, -12881, -7837, -7371, -8036, -12587, -12973, -13005, -13174, -13249, -8581, -7915, -8160, -7460, -11591, -14023, -14232, -10544, -8577, -8918, -10778, -14739, -14367, -14822, -15895, -12850, -10459, -11698, -11658, -13906, -18510, -18410, -18804, -14300, -13445, -13839, -13915, -14009, -14076, -14118, -14131, -14128, -14051, -13479, -13880, -15351, -14540, -14428, -14543, -15088, -15585, -15764, -15750, -15742, -15938, -15460, -15044, -15156, -15103, -15022, -14921, -14760, -14506, -14181, -13829, -13479, -13128, -12766, -12394, -12025, -11745, -11233, -10712, -10738, -9942, -4980, -4672, -4655, -4591, -4563, -4551, -4541, -4518, -4490, -4442, -4334, -4186, -3974, -4804, -1787, 12090, 11584, 5140, 4946, 5658, 6269, 6988, 7771, 8603, 9467, 10332, 11263, 12208, 11459, 9771, 7656, 7718, 8841, -6194, -8548, -6208, -5584, -5209, -4939, -4450, -4075, -3747, -3459, -3209, -3012, -2865, -2785, -2573, -2999, -9652, -10254, -10013};