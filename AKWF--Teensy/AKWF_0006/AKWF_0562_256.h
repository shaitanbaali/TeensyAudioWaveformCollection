/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0562 256 samples */
 
const int16_t AKWF_0562_256_DATA [256] = 
{-11828, -30721, -32711, -30535, -28336, -26273, -24429, -22807, -21373, -20099, -18969, -17954, -17042, -16218, -15467, -14783, -14157, -13577, -13040, -12542, -12076, -11640, -11230, -10844, -10478, -10131, -9802, -9488, -9188, -8902, -8627, -8364, -8111, -7868, -7635, -7409, -7191, -6982, -6780, -6584, -6395, -6211, -6035, -5862, -5696, -5534, -5377, -5225, -5076, -4932, -4792, -4657, -4524, -4394, -4269, -4145, -4026, -3909, -3795, -3683, -3573, -3466, -3362, -3260, -3159, -3060, -2964, -2869, -2776, -2685, -2595, -2506, -2419, -2334, -2250, -2165, -2084, -2003, -1922, -1843, -1766, -1687, -1611, -1536, -1461, -1386, -1313, -1239, -1167, -1095, -1024, -952, -882, -812, -742, -673, -604, -535, -468, -400, -332, -265, -197, -129, -63, 3, 69, 135, 202, 267, 334, 400, 465, 532, 598, 663, 728, 793, 859, 925, 990, 1056, 1121, 1186, 1251, 1316, 1381, 1447, 1512, 1578, 1644, 1708, 1774, 1839, 1905, 1971, 2035, 2101, 2167, 2233, 2299, 2364, 2430, 2496, 2562, 2627, 2694, 2760, 2825, 2892, 2957, 3024, 3090, 3156, 3222, 3289, 3355, 3422, 3489, 3555, 3622, 3688, 3755, 3821, 3888, 3954, 4022, 4089, 4156, 4222, 4289, 4356, 4424, 4491, 4558, 4625, 4692, 4760, 4826, 4894, 4962, 5028, 5096, 5164, 5231, 5298, 5366, 5433, 5500, 5569, 5636, 5703, 5772, 5839, 5907, 5975, 6042, 6110, 6178, 6246, 6314, 6381, 6450, 6517, 6585, 6653, 6721, 6789, 6857, 6925, 6993, 7061, 7129, 7197, 7265, 7333, 7402, 7469, 7537, 7606, 7673, 7741, 7810, 7878, 7946, 8015, 8083, 8150, 8219, 8288, 8356, 8423, 8492, 8560, 8629, 8696, 8765, 8833, 8902, 8969, 9038, 9106, 9175, 9243, 9311, 9379, 9448, 9516, 9585, 9653, 9720, 9789, 9857, 9857, 10298, 8365};