/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0570 256 samples */
 
const int16_t AKWF_0570_256_DATA [256] = 
{189, 822, 1472, 2146, 2839, 3549, 4274, 5010, 5757, 6513, 7274, 8042, 8816, 9589, 10365, 11143, 11918, 12693, 13464, 14230, 14993, 15749, 16497, 17239, 17971, 18694, 19407, 20107, 20795, 21473, 22134, 22782, 23415, 24031, 24631, 25215, 25779, 26326, 26854, 27362, 27850, 28318, 28765, 29189, 29592, 29971, 30329, 30663, 30974, 31260, 31522, 31760, 31974, 32162, 32325, 32463, 32575, 32662, 32721, 32764, 32728, 32389, 31931, 31430, 30892, 30329, 29745, 29143, 28528, 27900, 27259, 26610, 25953, 25286, 24613, 23930, 23243, 22553, 21860, 21165, 20472, 19779, 19091, 18406, 17725, 17050, 16383, 15720, 15067, 14424, 13788, 13164, 12552, 11949, 11361, 10785, 10221, 9674, 9141, 8623, 8121, 7635, 7166, 6715, 6281, 5866, 5470, 5093, 4735, 4397, 4079, 3780, 3504, 3248, 3013, 2800, 2608, 2439, 2291, 2165, 2061, 1981, 1919, 1893, 1830, 1473, 989, 458, -115, -717, -1344, -1992, -2655, -3333, -4022, -4720, -5440, -6176, -6918, -7670, -8426, -9186, -9949, -10714, -11478, -12243, -13006, -13765, -14522, -15274, -16017, -16758, -17489, -18211, -18926, -19629, -20321, -21003, -21671, -22326, -22967, -23594, -24204, -24799, -25376, -25936, -26480, -27002, -27506, -27990, -28453, -28896, -29316, -29714, -30090, -30444, -30772, -31077, -31359, -31615, -31846, -32052, -32232, -32387, -32515, -32617, -32691, -32738, -32769, -32566, -32146, -31675, -31158, -30609, -30032, -29433, -28815, -28182, -27534, -26877, -26207, -25529, -24847, -24157, -23463, -22768, -22070, -21370, -20673, -19976, -19281, -18591, -17904, -17222, -16548, -15878, -15217, -14566, -13923, -13290, -12668, -12058, -11460, -10875, -10302, -9745, -9203, -8676, -8165, -7670, -7192, -6733, -6292, -5868, -5465, -5081, -4716, -4372, -4049, -3746, -3465, -3206, -2968, -2753, -2559, -2389, -2242, -2117, -2015, -1937, -1878, -1855, -1797, -1436, -942, -385};