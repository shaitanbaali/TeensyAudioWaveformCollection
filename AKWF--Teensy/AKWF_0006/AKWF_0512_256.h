/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0512 256 samples */
 
const int16_t AKWF_0512_256_DATA [256] = 
{291, 1244, 2179, 3116, 4053, 4668, 7380, -259, -16105, -13338, -12735, -11797, -10858, -9923, -8984, -8045, -7110, -6171, -5233, -4297, -3358, -2420, -1485, -546, 391, 1328, 2183, 3517, 3030, -15854, -16797, -15359, -14521, -13583, -12647, -11707, -10771, -9834, -8895, -7958, -7021, -6082, -5146, -4208, -3269, -2333, -1395, -457, 122, 3006, -12349, -20646, -17842, -17245, -16309, -15370, -14433, -13496, -12557, -11619, -10684, -9744, -8807, -7870, -6931, -5994, -5057, -4118, -3182, -2244, -1305, -369, 567, 1506, 2442, 3380, 4319, 5255, 6194, 7132, 8068, 9007, 9945, 10881, 11819, 12757, 13694, 14633, 15570, 16506, 17362, 18696, 18209, -676, -1619, -181, 657, 1594, 2531, 3470, 4407, 5344, 6283, 7219, 8157, 9096, 10032, 10970, 11908, 12845, 13783, 14722, 15300, 18184, 2829, -5468, -2663, -2066, -1130, -192, 745, 1682, 2620, 3558, 4494, 5434, 6370, 7307, 8246, 9183, 10120, 11059, 11996, 12612, 15323, 7683, -8162, -5395, -4792, -3854, -2915, -1979, -1041, -103, 832, 1771, 2709, 3645, 4584, 5522, 6458, 7397, 8335, 9271, 10210, 11148, 12084, 13023, 13960, 14897, 15836, 16773, 17710, 18649, 19585, 20523, 21462, 22398, 23336, 24275, 25211, 26149, 27087, 28023, 28962, 29900, 30480, 33364, 18008, 9710, 12515, 13111, 14047, 14986, 15924, 16860, 17799, 18737, 19673, 20612, 21549, 22486, 23425, 24362, 25299, 26238, 27175, 27240, 32981, 10687, -33839, -27947, -27913, -26975, -26037, -25101, -24162, -23224, -22288, -21349, -20411, -19475, -18537, -17598, -16662, -15724, -14786, -13850, -12995, -11660, -12147, -31032, -31976, -30538, -29699, -28762, -27825, -26886, -25950, -25012, -24074, -23137, -22199, -21261, -20324, -19386, -18448, -17512, -16573, -15635, -14699, -13760, -12822, -11886, -10948, -10009, -9074, -8135, -7197, -6261, -5322, -4384, -3448, -2510, -1576, -621};