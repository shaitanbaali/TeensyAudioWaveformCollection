/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0537 256 samples */
 
const int16_t AKWF_0537_256_DATA [256] = 
{3015, -10502, -16040, -1463, -3932, 4245, 10725, 13025, 12484, 9963, 6421, 2674, -673, -3249, -4915, -5677, -5673, -5130, -4292, -3371, -2509, -1781, -1205, -750, -372, -22, 333, 692, 1025, 1295, 1475, 1543, 1463, 1216, 816, 324, -175, -617, -947, -1117, -1103, -911, -573, -144, 320, 757, 1109, 1334, 1419, 1376, 1225, 993, 717, 428, 154, -84, -278, -421, -515, -573, -601, -605, -515, -850, -1019, -3258, -4564, -3114, -798, 1531, 3299, 4204, 4225, 3501, 2293, 902, -390, -1377, -1968, -2150, -1988, -1600, -1114, -637, -241, 34, 192, 255, 263, 254, 268, 337, 476, 664, 864, 1033, 1137, 1150, 1057, 828, 458, -38, -608, -1174, -1649, -1967, -2095, -2029, -1771, -1350, -810, -219, 354, 850, 1227, 1459, 1545, 1499, 1351, 1137, 892, 642, 410, 205, 36, -97, -161, -272, -1855, 1102, -12792, -12908, -2429, -5262, 4013, 9750, 11976, 11581, 9415, 6367, 3160, 295, -1954, -3448, -4185, -4289, -3943, -3353, -2683, -2056, -1544, -1171, -931, -799, -738, -711, -678, -605, -481, -301, -77, 179, 444, 693, 901, 1055, 1146, 1177, 1156, 1088, 987, 860, 719, 574, 428, 285, 147, 15, -107, -212, -298, -359, -392, -392, -350, -259, -117, 61, 254, 434, 570, 631, 598, 456, 192, -196, -672, -1164, -1590, -1886, -2020, -1974, -1739, -1332, -796, -196, 402, 938, 1362, 1640, 1762, 1743, 1606, 1389, 1125, 846, 576, 331, 122, -46, -176, -273, -346, -402, -442, -464, -474, -472, -461, -439, -406, -357, -297, -237, -191, -172, -186, -231, -292, -349, -388, -396, -362, -284, -164, -21, 129, 270, 385, 470, 521, 541, 528, 502, 392, 699};