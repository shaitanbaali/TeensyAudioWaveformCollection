/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0587 256 samples */
 
const int16_t AKWF_0587_256_DATA [256] = 
{1123, 3528, 5976, 8438, 10773, 12875, 14665, 16108, 17214, 17990, 18482, 18759, 18898, 18983, 19083, 19226, 19412, 19608, 19801, 19967, 20008, 19819, 19377, 18710, 17854, 16831, 15685, 14471, 13249, 12067, 10959, 9929, 8943, 7927, 6755, 5316, 3589, 1619, -530, -2765, -5002, -7148, -9105, -10807, -12238, -13289, -13983, -14424, -14659, -14733, -14682, -14534, -14295, -13954, -13507, -12951, -12294, -11539, -10698, -9796, -8864, -7942, -7069, -6276, -5571, -4950, -4409, -3883, -3268, -2479, -1470, -245, 1171, 2754, 4430, 6130, 7763, 9235, 10477, 11449, 12144, 12585, 12775, 12736, 12549, 12306, 12019, 11658, 11191, 10598, 9835, 8870, 7664, 6192, 4457, 2492, 342, -1915, -4240, -6595, -8941, -11331, -13065, -18750, -27281, -31829, -32733, -30441, -26051, -20993, -16675, -14233, -14196, -16351, -19838, -23364, -25483, -25072, -21656, -15739, -13207, -12127, -10584, -8981, -7270, -5436, -3477, -1379, 863, 3218, 5673, 8151, 10513, 12655, 14498, 16002, 17177, 18026, 18591, 18942, 19150, 19302, 19463, 19666, 19908, 20155, 20394, 20601, 20673, 20506, 20074, 19406, 18539, 17494, 16320, 15073, 13812, 12587, 11438, 10367, 9339, 8279, 7063, 5576, 3802, 1787, -402, -2673, -4936, -7102, -9072, -10784, -12193, -13278, -14054, -14552, -14812, -14871, -14764, -14523, -14149, -13622, -12932, -12078, -11076, -9933, -8675, -7346, -6002, -4704, -3523, -2498, -1643, -948, -402, 90, 668, 1441, 2458, 3696, 5115, 6666, 8255, 9796, 11185, 12329, 13166, 13669, 13854, 13766, 13425, 12869, 12192, 11490, 10781, 10032, 9221, 8331, 7327, 6184, 4874, 3377, 1704, -118, -2048, -4026, -6022, -8006, -9959, -11943, -13260, -18743, -27293, -31837, -32740, -30447, -26058, -21000, -16682, -14238, -14201, -16356, -19843, -23368, -25488, -25076, -21660, -15744, -13211, -12130, -10588, -8986, -7273, -5444, -3492, -1351};