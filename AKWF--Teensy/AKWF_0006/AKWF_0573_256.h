/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0573 256 samples */
 
const int16_t AKWF_0573_256_DATA [256] = 
{2796, 11359, 19036, 25144, 28911, 29955, 29900, 29918, 29920, 29920, 29920, 29920, 29920, 29920, 29920, 29920, 29920, 29920, 29920, 29920, 29917, 29916, 29916, 29913, 29911, 29908, 29905, 29902, 29899, 29895, 29891, 29885, 29878, 29872, 29866, 29859, 29849, 29843, 29836, 29825, 29812, 29804, 29795, 29782, 29771, 29759, 29746, 29733, 29721, 29705, 29691, 29676, 29661, 29646, 29629, 29611, 29596, 29577, 29556, 29537, 29517, 29496, 29473, 29448, 29423, 29398, 29372, 29342, 29312, 29282, 29252, 29218, 29185, 29148, 29113, 29076, 29038, 29000, 28961, 28920, 28878, 28837, 28795, 28752, 28709, 28666, 28625, 28582, 28540, 28499, 28457, 28417, 28379, 28339, 28303, 28269, 28236, 28203, 28173, 28142, 28115, 28091, 28067, 28045, 28025, 28007, 27988, 27973, 27960, 27950, 27937, 27928, 27922, 27915, 27910, 27907, 27905, 27903, 27904, 27901, 27899, 27896, 27892, 27888, 27882, 27876, 27871, 27863, 27854, 27845, 27833, 27821, 27808, 27792, 27777, 27756, 27735, 27710, 27682, 27654, 27620, 27584, 27541, 27496, 27445, 27388, 27328, 27259, 27183, 27102, 27013, 26915, 26810, 26695, 26570, 26438, 26294, 26138, 25972, 25798, 25607, 25406, 25195, 24967, 24729, 24477, 24212, 23935, 23643, 23335, 23015, 22683, 22336, 21976, 21600, 21213, 20812, 20400, 19974, 19538, 19089, 18626, 18157, 17674, 17183, 16684, 16171, 15652, 15126, 14587, 14044, 13493, 12932, 12370, 11798, 11219, 10637, 10047, 9451, 8854, 8252, 7646, 7036, 6425, 5811, 5199, 4585, 3975, 3369, 2766, 2167, 1579, 1000, 431, -121, -658, -1178, -1677, -2155, -2607, -3030, -3426, -3786, -4114, -4407, -4659, -4910, -5017, -5068, -28510, -32861, -31775, -31967, -31958, -31928, -31872, -31772, -31618, -31410, -31151, -30856, -30551, -30266, -30029, -29872, -29815, -29814, -29799, -29692, -29320, -28399, -26576, -23508, -18952, -12873, -5272};