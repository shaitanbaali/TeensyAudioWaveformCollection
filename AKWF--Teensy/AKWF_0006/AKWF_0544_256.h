/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0544 256 samples */
 
const int16_t AKWF_0544_256_DATA [256] = 
{18472, 29703, 24438, 19960, 21042, 19459, 15364, 12056, 20384, 19171, 15766, 12305, 12322, 11094, 8068, 2804, 17947, 20019, 15053, 12599, 13506, 10455, 7863, 3326, 10339, 11738, 7535, 3548, 5509, 2168, -1306, -4790, 15539, 20386, 16309, 11612, 12691, 11107, 7012, 3704, 12033, 10820, 7415, 3953, 3970, 2742, -283, -5546, 9596, 11668, 6701, 4247, 5155, 2104, -488, -5024, 1987, 3387, -816, -4802, -2842, -6174, -9603, -13415, 13677, 20790, 16220, 11610, 12691, 11107, 7013, 3705, 12034, 10820, 7414, 3953, 3971, 2742, -283, -5546, 9596, 11668, 6702, 4247, 5155, 2104, -488, -5024, 1988, 3387, -815, -4802, -2841, -6183, -9656, -13141, 7188, 12036, 7959, 3261, 4340, 2756, -1338, -4646, 3682, 2469, -936, -4396, -4379, -5608, -8633, -13897, 1245, 3317, -1649, -4103, -3195, -6246, -8839, -13375, -6363, -4962, -9165, -13153, -11194, -14519, -17883, -22108, 11859, 21201, 16130, 11609, 12691, 11108, 7013, 3704, 12033, 10820, 7415, 3954, 3971, 2742, -282, -5545, 9596, 11669, 6702, 4247, 5156, 2104, -488, -5024, 1988, 3387, -815, -4802, -2841, -6183, -9656, -13141, 7189, 12036, 7959, 3261, 4340, 2756, -1337, -4646, 3682, 2469, -936, -4396, -4379, -5608, -8633, -13897, 1245, 3316, -1649, -4103, -3195, -6246, -8839, -13375, -6363, -4963, -9166, -13153, -11193, -14524, -17953, -21765, 5328, 12439, 7869, 3260, 4340, 2756, -1337, -4646, 3683, 2469, -936, -4396, -4379, -5608, -8633, -13897, 1245, 3316, -1649, -4103, -3194, -6246, -8839, -13375, -6363, -4963, -9165, -13153, -11192, -14533, -18007, -21491, -1161, 3684, -392, -5089, -4011, -5594, -9688, -12997, -4667, -5882, -9288, -12747, -12730, -13959, -16984, -22248, -7105, -5033, -9999, -12453, -11546, -14597, -17190, -21726, -14714, -13314, -17517, -21504, -19545, -22971, -26235, -30143};