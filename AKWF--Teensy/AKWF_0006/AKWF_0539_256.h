/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0539 256 samples */
 
const int16_t AKWF_0539_256_DATA [256] = 
{6369, 13789, 18237, 20405, 20751, 19728, 17768, 15273, 12554, 9834, 7246, 4831, 2606, 587, -1234, -2843, -4219, -5357, -6244, -6873, -7251, -7385, -7289, -6989, -6507, -5878, -5131, -4300, -3417, -2507, -1602, -728, 96, 851, 1559, 1856, 3734, 2782, -6976, -7896, -3212, 2804, 7895, 11041, 12190, 11778, 10346, 8345, 6127, 3944, 1991, 388, -833, -1684, -2217, -2498, -2580, -2506, -2322, -2078, -1836, -1636, -1501, -1433, -1420, -1438, -1465, -1481, -1467, -1414, -1314, -1174, -994, -785, -555, -312, -125, 622, -2030, 3721, 17494, 16721, 9288, 513, -6619, -10881, -12383, -11833, -9985, -7459, -4711, -2096, 143, 1880, 3084, 3814, 4164, 4235, 4109, 3847, 3493, 3077, 2618, 2134, 1636, 1135, 646, 175, -264, -662, -1014, -1307, -1542, -1717, -1830, -1884, -1883, -1936, -1244, -4173, -5456, -1362, -4339, -8931, -12196, -13324, -12488, -10197, -6952, -3181, 770, 4588, 7967, 10684, 12596, 13660, 13931, 13525, 12583, 11247, 9655, 7927, 6154, 4408, 2731, 1122, -412, -1861, -3210, -4425, -5468, -6311, -6924, -7294, -7420, -7308, -6976, -6450, -5762, -4949, -4045, -3116, -1861, -2122, -1306, 14229, 18731, 13242, 4977, -2519, -7446, -9573, -9469, -7909, -5554, -2909, -358, 1846, 3534, 4653, 5257, 5313, 5718, 3313, -4355, -8425, -11510, -12733, -12293, -7668, -9555, -15382, -10367, -1231, 8080, 15308, 19591, 21116, 20495, 18397, 15386, 11916, 8363, 4983, 1958, -582, -3038, -2477, -9361, -18530, -17576, -12588, -6780, -2046, 916, 2253, 2422, 1896, 1045, 141, -623, -1124, -1305, -1176, -802, -258, 376, 1046, 1700, 2295, 2777, 3098, 3235, 3186, 2971, 2623, 2180, 1686, 1174, 677, 223, -177, -513, -779, -964, -1153, -1040, 1109, -2122, -8596, -13553, -27457, -32784, -26233, -15127, -3281};