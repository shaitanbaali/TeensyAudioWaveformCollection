/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0561 256 samples */
 
const int16_t AKWF_0561_256_DATA [256] = 
{-18260, -32559, -32211, -30395, -28624, -27013, -25614, -24415, -23382, -22490, -21718, -21042, -20453, -19932, -19469, -19056, -18684, -18346, -18036, -17752, -17486, -17238, -17004, -16781, -16570, -16366, -16168, -15978, -15792, -15609, -15430, -15255, -15081, -14911, -14740, -14572, -14405, -14239, -14074, -13910, -13746, -13582, -13420, -13257, -13094, -12932, -12770, -12608, -12447, -12285, -12123, -11962, -11801, -11639, -11479, -11317, -11156, -10995, -10834, -10674, -10512, -10351, -10190, -10029, -9868, -9707, -9546, -9385, -9225, -9063, -8902, -8742, -8581, -8419, -8259, -8098, -7937, -7776, -7615, -7454, -7294, -7132, -6971, -6811, -6650, -6488, -6328, -6167, -6006, -5845, -5684, -5523, -5362, -5201, -5040, -4880, -4719, -4558, -4397, -4236, -4075, -3914, -3753, -3592, -3431, -3270, -3109, -2949, -2787, -2627, -2466, -2304, -2144, -1983, -1822, -1661, -1500, -1339, -1178, -1017, -856, -696, -535, -373, -212, -52, 108, 270, 430, 591, 752, 914, 1074, 1234, 1396, 1557, 1718, 1878, 2039, 2201, 2362, 2522, 2683, 2845, 3005, 3166, 3327, 3488, 3649, 3809, 3970, 4132, 4293, 4453, 4614, 4776, 4936, 5097, 5258, 5419, 5580, 5740, 5902, 6063, 6224, 6384, 6545, 6706, 6867, 7028, 7188, 7350, 7511, 7671, 7832, 7994, 8155, 8315, 8476, 8638, 8799, 8959, 9120, 9281, 9442, 9603, 9764, 9925, 10086, 10247, 10408, 10569, 10730, 10890, 11052, 11212, 11373, 11534, 11696, 11856, 12017, 12178, 12339, 12500, 12661, 12821, 12983, 13144, 13304, 13465, 13627, 13787, 13948, 14109, 14270, 14431, 14592, 14752, 14914, 15075, 15235, 15396, 15557, 15718, 15879, 16040, 16201, 16362, 16523, 16684, 16845, 17006, 17166, 17328, 17488, 17649, 17811, 17971, 18132, 18293, 18454, 18615, 18776, 18937, 19098, 19259, 19419, 19580, 19742, 19903, 20063, 20224, 20380, 20319, 21732, 11534};