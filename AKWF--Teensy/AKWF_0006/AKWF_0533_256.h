/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0533 256 samples */
 
const int16_t AKWF_0533_256_DATA [256] = 
{180, 530, 872, 1214, 1558, 1900, 2243, 2585, 2929, 3271, 3613, 3955, 4298, 4640, 4982, 5324, 5665, 6008, 6349, 6691, 7031, 7374, 7714, 8056, 8396, 8738, 9079, 9420, 9758, 10100, 10439, 10783, 11113, 11176, 11160, 11161, 11158, 11156, 11169, 11096, 11495, 12657, 14558, 14843, 15193, 15533, 15873, 16211, 16550, 16889, 17228, 17566, 17906, 18244, 18583, 18921, 19260, 19597, 19936, 20275, 20613, 20952, 21288, 21627, 21964, 22302, 22640, 22977, 23314, 23651, 23990, 24325, 24662, 24999, 25337, 25673, 26010, 26346, 26683, 27020, 27355, 27692, 28028, 28363, 28700, 29035, 29370, 29707, 30043, 30376, 30713, 31048, 31382, 31718, 32048, 32394, 32681, 31849, 30681, 29578, 28466, 27356, 26247, 25142, 24036, 22932, 21833, 20734, 19635, 18542, 17448, 16356, 15269, 14180, 13093, 12012, 10930, 9850, 8775, 7697, 6624, 5556, 4484, 3417, 2354, 1289, 229, -829, -1887, -2940, -3994, -5047, -6093, -7140, -8186, -9228, -10268, -11309, -12342, -13377, -14411, -15437, -16474, -17445, -18315, -19197, -20084, -20973, -21869, -22766, -23668, -24577, -25491, -26398, -27357, -27929, -28666, -29616, -30525, -31460, -32353, -32264, -31876, -31549, -31211, -30873, -30536, -30200, -29864, -29528, -29195, -28862, -28527, -28195, -27864, -27532, -27202, -26871, -26541, -26214, -25885, -25558, -25231, -24905, -24580, -24255, -23930, -23606, -23285, -22961, -22632, -22268, -21892, -21521, -21152, -20782, -20417, -20052, -19687, -19326, -18967, -18608, -18252, -17897, -17542, -17192, -16842, -16492, -16147, -15802, -15458, -15116, -14759, -14538, -11487, -10666, -10849, -10810, -10806, -10802, -10798, -10796, -10790, -10789, -10775, -10495, -10139, -9796, -9450, -9106, -8760, -8415, -8071, -7726, -7382, -7037, -6692, -6347, -6003, -5657, -5313, -4969, -4624, -4281, -3936, -3592, -3248, -2904, -2560, -2217, -1873, -1528, -1186, -842, -500, -151};