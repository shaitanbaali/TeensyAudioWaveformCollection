/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0589 256 samples */
 
const int16_t AKWF_0589_256_DATA [256] = 
{97, 407, 711, 1015, 1319, 1623, 1927, 2230, 2534, 2837, 3139, 3442, 3746, 4048, 4351, 4653, 4955, 5257, 5559, 5860, 6162, 6464, 6764, 7065, 7367, 7667, 7968, 8268, 8568, 8868, 9168, 9467, 9767, 10067, 10366, 10665, 10964, 11263, 11561, 11859, 12157, 12456, 12753, 13052, 13349, 13646, 13943, 14241, 14538, 14835, 15131, 15428, 15724, 16021, 16316, 16612, 16908, 17203, 17499, 17794, 18089, 18384, 18678, 18973, 19268, 19562, 19856, 20150, 20444, 20738, 21031, 21324, 21617, 21910, 22203, 22495, 22788, 23080, 23373, 23665, 23956, 24249, 24540, 24831, 25122, 25414, 25704, 25995, 26286, 26576, 26866, 27157, 27446, 27736, 28026, 28316, 28605, 28893, 29183, 29473, 29755, 30058, 30286, 29452, 28330, 27264, 26190, 25115, 24038, 22964, 21888, 20812, 19739, 18665, 17591, 16519, 15443, 14371, 13300, 12227, 11155, 10086, 9014, 7943, 6875, 5804, 4736, 3668, 2599, 1533, 467, -600, -1664, -2729, -3795, -4857, -5921, -6985, -8046, -9108, -10170, -11230, -12291, -13351, -14408, -15468, -16527, -17582, -18640, -19697, -20751, -21807, -22862, -23915, -24969, -26023, -27073, -28126, -29177, -30226, -31264, -32376, -32611, -32164, -31809, -31436, -31063, -30691, -30318, -29943, -29570, -29196, -28821, -28448, -28074, -27700, -27327, -26952, -26578, -26205, -25830, -25456, -25083, -24710, -24337, -23963, -23590, -23216, -22844, -22470, -22098, -21726, -21353, -20981, -20609, -20237, -19866, -19494, -19122, -18752, -18380, -18008, -17638, -17269, -16898, -16528, -16158, -15788, -15419, -15049, -14680, -14311, -13942, -13573, -13205, -12836, -12469, -12102, -11734, -11366, -10998, -10668, -10361, -10051, -9740, -9430, -9121, -8810, -8500, -8192, -7882, -7573, -7265, -6956, -6648, -6339, -6031, -5723, -5415, -5108, -4800, -4493, -4186, -3880, -3573, -3266, -2960, -2653, -2347, -2042, -1736, -1430, -1125, -820, -516, -206};