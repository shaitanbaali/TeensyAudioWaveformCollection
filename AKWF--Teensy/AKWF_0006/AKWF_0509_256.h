/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0509 256 samples */
 
const int16_t AKWF_0509_256_DATA [256] = 
{450, 1105, 1747, 2389, 3029, 3669, 4307, 4941, 5574, 6204, 6828, 7451, 8071, 8683, 9292, 9897, 10495, 11089, 11677, 12256, 12830, 13398, 13958, 14511, 15056, 15591, 16119, 16639, 17149, 17651, 18142, 18624, 19096, 19557, 20008, 20448, 20877, 21296, 21703, 22097, 22363, 23407, 14622, 11607, 12679, 12869, 13178, 13473, 13756, 14025, 14282, 14523, 14753, 14968, 15169, 15357, 15530, 15689, 15835, 15966, 16083, 16467, 15037, 23258, 33950, 32423, 32747, 32765, 32768, 32757, 32731, 32692, 32638, 32571, 32490, 32395, 32286, 32165, 32029, 31880, 31717, 31542, 31354, 31153, 30939, 30713, 30475, 30224, 29962, 29688, 29402, 29105, 28797, 28478, 28149, 27809, 27458, 27098, 26729, 26350, 25962, 25565, 25159, 24746, 24324, 23893, 23457, 23012, 22561, 22104, 21640, 21171, 20696, 20216, 19730, 19242, 18747, 18249, 17747, 17242, 16735, 16226, 15712, 15197, 14683, 13715, 15620, 2110, -15389, -13403, -14387, -14904, -15418, -15932, -16444, -16952, -17458, -17963, -18462, -18959, -19451, -19938, -20422, -20900, -21372, -21839, -22301, -22755, -23203, -23644, -24078, -24505, -24923, -25333, -25736, -26129, -26513, -26888, -27253, -27609, -27956, -28291, -28615, -28930, -29234, -29525, -29807, -30076, -30332, -30578, -30811, -31032, -31241, -31435, -31618, -31788, -31945, -32088, -32218, -32334, -32437, -32526, -32602, -32663, -32710, -32744, -32763, -32768, -32759, -32452, -33935, -25737, -15039, -16531, -16144, -16035, -15912, -15775, -15624, -15458, -15279, -15085, -14878, -14657, -14423, -14174, -13913, -13638, -13349, -13048, -12812, -12064, -13444, -22989, -22735, -22298, -21931, -21531, -21119, -20696, -20263, -19817, -19362, -18896, -18420, -17934, -17439, -16933, -16419, -15896, -15364, -14825, -14276, -13720, -13158, -12587, -12010, -11428, -10837, -10241, -9641, -9034, -8422, -7808, -7187, -6563, -5937, -5305, -4672, -4037, -3397, -2756, -2116, -1473, -832, -177};