/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0531 256 samples */
 
const int16_t AKWF_0531_256_DATA [256] = 
{9565, 11169, 11037, 11061, 11062, 11064, 11065, 11065, 11063, 11063, 11062, 11061, 11059, 11058, 11057, 11055, 11053, 11052, 11050, 11047, 11045, 11043, 11041, 11039, 11036, 11033, 11031, 11028, 11026, 11023, 11021, 11018, 11015, 11012, 11010, 11007, 11004, 11001, 10998, 10994, 10992, 10989, 10987, 10985, 10982, 10979, 10977, 10974, 10971, 10967, 10964, 10961, 10958, 10955, 10952, 10950, 10947, 10944, 10941, 10938, 10935, 10932, 10928, 10926, 10924, 10920, 11065, 10323, 15710, 25933, 31489, 32663, 32444, 32492, 32487, 32482, 32475, 32469, 32463, 32457, 32450, 32442, 32435, 32427, 32420, 32413, 32406, 32399, 32390, 32382, 32374, 32367, 32359, 32350, 32342, 32333, 32325, 32316, 32308, 32301, 32292, 32284, 32274, 32266, 32259, 32250, 32241, 32233, 32225, 32216, 32206, 32198, 32190, 32181, 32173, 32165, 32155, 32147, 32138, 32131, 32122, 32112, 32091, 32053, 32223, 26421, 18408, 7798, -29457, -33512, -32549, -32765, -32767, -32768, -32767, -32768, -32767, -32766, -32765, -32762, -32758, -32754, -32750, -32745, -32738, -32734, -32729, -32721, -32715, -32708, -32702, -32694, -32687, -32680, -32674, -32667, -32658, -32650, -32642, -32635, -32627, -32619, -32612, -32603, -32594, -32587, -32578, -32570, -32561, -32552, -32544, -32536, -32527, -32518, -32511, -32502, -32494, -32486, -32476, -32468, -32460, -32419, -32548, -31720, -28684, -26030, -21714, -11971, -10665, -10829, -10776, -10768, -10762, -10756, -10751, -10745, -10740, -10736, -10731, -10726, -10722, -10717, -10713, -10709, -10705, -10701, -10697, -10694, -10691, -10686, -10683, -10680, -10677, -10673, -10669, -10666, -10663, -10660, -10657, -10654, -10652, -10648, -10644, -10641, -10638, -10635, -10632, -10629, -10627, -10624, -10621, -10618, -10615, -10612, -10610, -10606, -10604, -10601, -10598, -10595, -10591, -10589, -10585, -10583, -10581, -10577, -10574, -10571, -10568, -10566, -10563, -10560, -10558, -10404, -11211, -6864};