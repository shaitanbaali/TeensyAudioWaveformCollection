/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0501 256 samples */
 
const int16_t AKWF_0501_256_DATA [256] = 
{31083, 31089, 31095, 31098, 31101, 31103, 31104, 31104, 31103, 31101, 31099, 31097, 31093, 31090, 31086, 31082, 31077, 31071, 31066, 31060, 31054, 31048, 31041, 31035, 31028, 31021, 31014, 31008, 31000, 30993, 30986, 30978, 30970, 30963, 30955, 30947, 30940, 30932, 30924, 30916, 30909, 30900, 30892, 30885, 30876, 30868, 30861, 30851, 30844, 30836, 30828, 30819, 30812, 30803, 30796, 30787, 30778, 30771, 30762, 30755, 30746, 30738, 30730, 30721, 30714, 30704, 30697, 30689, 30680, 30672, 30663, 30656, 30647, 30640, 30631, 30622, 30615, 30606, 30598, 30590, 30581, 30574, 30565, 30557, 30549, 30541, 30532, 30524, 30517, 30507, 30500, 30492, 30483, 30475, 30467, 30459, 30450, 30443, 30434, 30426, 30418, 30410, 30402, 30393, 30385, 30377, 30370, 30360, 30353, 30345, 30336, 30329, 30321, 30312, 30304, 30296, 30287, 30280, 30272, 30263, 30255, 30247, 30239, 30231, 29405, 33949, 12596, -36454, -31948, -32762, -32765, -32767, -32768, -32768, -32767, -32766, -32765, -32761, -32758, -32754, -32750, -32745, -32741, -32735, -32729, -32724, -32717, -32711, -32704, -32697, -32690, -32683, -32676, -32669, -32661, -32653, -32645, -32637, -32629, -32621, -32614, -32605, -32598, -32589, -32581, -32573, -32564, -32549, -31894, -35613, 15130, 33794, 29703, 29407, 35014, -10026, -36886, -31519, -32499, -32495, -32490, -32486, -32481, -32475, -32469, -32463, -32456, -32450, -32443, -32436, -32429, -32422, -32414, -32406, -32399, -32392, -32383, -32376, -32368, -32360, -32352, -32344, -32335, -32328, -32319, -32311, -32303, -32294, -32286, -32278, -32269, -32260, -32253, -32244, -32235, -32226, -32219, -32210, -32201, -32192, -32185, -32176, -32166, -32158, -32151, -32141, -32133, -32124, -32115, -32108, -32099, -32089, -32081, -32073, -32064, -32056, -32046, -32038, -32031, -32021, -32012, -32004, -31996, -31987, -31978, -31969, -31961, -31953, -31944, -31935, -31926, -31919, -31910, -31901, -31892, -31885};