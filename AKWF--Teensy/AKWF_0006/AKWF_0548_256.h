/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0548 256 samples */
 
const int16_t AKWF_0548_256_DATA [256] = 
{693, 2352, 3959, 5581, 7248, 8981, 10781, 12627, 14494, 16347, 18155, 19921, 21639, 23293, 24841, 26234, 27459, 28523, 29455, 30268, 30970, 31561, 32035, 32389, 32625, 32748, 32764, 32691, 32528, 32234, 31728, 30931, 29794, 28339, 26618, 24701, 22677, 20614, 18567, 16588, 14695, 12894, 11223, 9691, 8330, 7145, 6089, 5120, 4220, 3376, 2610, 1924, 1310, 764, 279, -148, -510, -788, -962, -995, -872, -619, -308, -21, 194, 338, 444, 549, 697, 914, 1205, 1572, 1991, 2435, 2886, 3348, 3825, 4312, 4770, 5156, 5455, 5684, 5867, 6022, 6152, 6258, 6329, 6358, 6348, 6290, 6192, 6060, 5891, 5633, 5205, 4515, 3511, 2209, 659, -1078, -2913, -4787, -6644, -8433, -10137, -11749, -13233, -14575, -15745, -16732, -17574, -18316, -18972, -19541, -20005, -20352, -20584, -20701, -20709, -20604, -20368, -19993, -19442, -18691, -17717, -16548, -15259, -13938, -12633, -11356, -10074, -8756, -7376, -5907, -4356, -2737, -1074, 591, 2230, 3841, 5422, 6955, 8398, 9698, 10843, 11843, 12717, 13484, 14151, 14712, 15164, 15502, 15730, 15848, 15864, 15790, 15631, 15343, 14846, 14055, 12922, 11471, 9754, 7836, 5812, 3749, 1694, -294, -2200, -4014, -5703, -7257, -8644, -9854, -10938, -11937, -12871, -13749, -14548, -15266, -15912, -16488, -17003, -17460, -17842, -18138, -18322, -18360, -18236, -17972, -17640, -17321, -17063, -16866, -16691, -16505, -16259, -15928, -15504, -14991, -14403, -13775, -13118, -12430, -11703, -10947, -10196, -9497, -8858, -8272, -7706, -7150, -6592, -6038, -5496, -4973, -4471, -3997, -3542, -3103, -2685, -2335, -2141, -2197, -2549, -3192, -4073, -5127, -6278, -7453, -8608, -9696, -10697, -11601, -12382, -13026, -13496, -13792, -13952, -14019, -14011, -13928, -13752, -13473, -13096, -12616, -12047, -11382, -10606, -9708, -8656, -7423, -5993, -4385, -2685, -940};