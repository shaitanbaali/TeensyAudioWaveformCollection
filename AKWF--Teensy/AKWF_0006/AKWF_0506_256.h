/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0506 256 samples */
 
const int16_t AKWF_0506_256_DATA [256] = 
{20250, 25722, 24549, 24763, 24768, 24766, 24761, 24754, 24747, 24739, 24730, 24720, 24709, 24699, 24688, 24676, 24664, 24652, 24639, 24627, 24615, 24602, 24589, 24575, 24563, 24551, 24539, 24523, 24013, 26768, 14312, -29664, -28459, -28553, -28623, -28619, -28613, -28605, -28597, -28588, -28578, -28565, -28554, -28540, -28528, -28515, -28500, -28486, -28472, -28457, -28444, -28429, -28413, -28399, -28385, -28371, -28353, -27864, -30489, -18713, 25573, 24705, 24730, 24808, 24805, 24801, 24796, 24790, 24783, 24774, 24765, 24755, 24743, 24732, 24721, 24710, 24697, 24685, 24673, 24660, 24647, 24636, 24622, 24609, 24597, 24584, 24570, 24557, 24544, 24531, 24518, 24505, 24492, 24478, 24465, 24453, 24440, 24427, 24413, 24400, 24387, 24374, 24362, 24348, 24330, 23501, 27939, 4429, -32411, -27988, -28802, -28809, -28802, -28796, -28790, -28782, -28772, -28761, -28749, -28736, -28724, -28711, -28697, -28683, -28669, -28654, -28641, -28626, -28610, -28595, -28581, -28566, -28552, -28537, -28522, -28181, -29887, -22729, 22842, 25136, 24477, 24640, 24641, 24636, 24631, 24625, 24618, 24610, 24601, 24591, 24580, 24569, 24558, 24547, 24534, 24523, 24510, 24497, 24485, 24472, 24460, 24447, 24434, 24422, 24409, 24395, 24382, 24370, 24356, 24343, 24331, 24318, 24305, 24291, 24278, 24265, 24252, 24239, 24227, 24214, 24200, 24187, 24175, 24161, 24148, 24135, 24123, 24109, 24096, 24084, 24071, 24057, 24044, 24033, 24024, 23114, 27887, -5816, -32990, -28241, -29117, -29117, -29114, -29109, -29100, -29091, -29081, -29070, -29058, -29046, -29032, -29018, -29004, -28991, -28976, -28961, -28947, -28932, -28917, -28901, -28887, -28871, -28856, -28841, -28826, -28811, -28795, -28780, -28765, -28749, -28733, -28718, -28703, -28687, -28672, -28657, -28642, -28627, -28611, -28596, -28580, -28565, -28549, -28534, -28518, -28503, -28488, -28473, -28458, -28443, -28427, -28412, -28400, -28432, -28133, -29314};