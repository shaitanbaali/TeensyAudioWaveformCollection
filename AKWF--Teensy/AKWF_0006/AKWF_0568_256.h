/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0568 256 samples */
 
const int16_t AKWF_0568_256_DATA [256] = 
{1947, 5184, 7548, 9559, 11291, 12819, 14188, 15422, 16551, 17589, 18542, 19427, 20251, 21014, 21726, 22391, 23009, 23587, 24126, 24627, 25094, 25527, 25926, 26295, 26635, 26943, 27224, 27477, 27704, 27904, 28078, 28226, 28349, 28445, 28449, 28710, 28055, 8754, -264, -3587, -6637, -9036, -11058, -12824, -14391, -15799, -17080, -18255, -19335, -20337, -21267, -22132, -22941, -23697, -24402, -25065, -25685, -26263, -26806, -27313, -27784, -28225, -28633, -29011, -29361, -29681, -29974, -30240, -30478, -30692, -30880, -31042, -31180, -31294, -31379, -31229, -32360, -27331, -6925, -1246, 2378, 5262, 7599, 9584, 11324, 12869, 14255, 15517, 16668, 17723, 18696, 19594, 20424, 21195, 21906, 22565, 23176, 23738, 24257, 24734, 25170, 25566, 25925, 26247, 26534, 26785, 27002, 27187, 27336, 27453, 27374, 28260, 24397, 9556, 5517, 2862, 758, -953, -2413, -3700, -4847, -5886, -6838, -7713, -8522, -9278, -9984, -10645, -11267, -11852, -12405, -12927, -13421, -13887, -14330, -14748, -15144, -15519, -15873, -16209, -16526, -16824, -17106, -17370, -17617, -17850, -18066, -18267, -18453, -18625, -18782, -18925, -19054, -19170, -19272, -19359, -19434, -19497, -19545, -19479, -20007, -17769, -6159, -2598, -562, 1091, 2433, 3573, 4572, 5464, 6267, 7000, 7674, 8296, 8873, 9411, 9913, 10383, 10824, 11237, 11625, 11992, 12334, 12657, 12960, 13243, 13510, 13759, 13991, 14207, 14408, 14594, 14765, 14922, 15065, 15195, 15311, 15413, 15502, 15577, 15641, 15693, 15711, 15710, 16013, 5068, -1551, -3590, -5593, -7175, -8533, -9731, -10816, -11811, -12730, -13591, -14399, -15163, -15890, -16583, -17245, -17884, -18494, -19082, -19653, -20203, -20736, -21253, -21755, -22243, -22719, -23180, -23630, -24079, -24456, -24702, -24931, -25147, -25347, -25535, -25709, -25870, -26018, -26153, -26277, -26388, -26486, -26572, -26646, -26708, -26759, -26801, -26506, -28202, -16111, -1131};