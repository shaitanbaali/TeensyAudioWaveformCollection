/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0518 256 samples */
 
const int16_t AKWF_0518_256_DATA [256] = 
{1856, 7224, 16339, 24200, 25329, 21129, 14613, 11346, 9539, 8659, 7893, 6718, 4949, 3162, 145, -3251, -6805, -7111, -5096, -3256, -7980, -16231, -24332, -30006, -32335, -30375, -25252, -18224, -10603, -3407, 2728, 7634, 11409, 14154, 16058, 16191, 12602, 6517, 1394, 1196, 2343, 4301, 5738, 6077, 5352, 4042, 2791, 2142, 2369, 3163, 3963, 4907, 5519, 5170, 4368, 3340, 2451, 1997, 2131, 2834, 3948, 5247, 6475, 7417, 7881, 7834, 7591, 7356, 7143, 6963, 6819, 6708, 6634, 6611, 6662, 6819, 7101, 7528, 7964, 9155, 10296, 11052, 11439, 11747, 10085, 10041, 10055, 9586, 8494, 7280, 6266, 5543, 4941, 4322, 3736, 3267, 2960, 2727, 2827, 3005, 2913, 2994, 3182, 3438, 3713, 3994, 4295, 4632, 4941, 5459, 6062, 6248, 6362, 7057, 7933, 9680, 13077, 16802, 21139, 24825, 26471, 26426, 25117, 22975, 20501, 18357, 15961, 13598, 11194, 8820, 7068, 5779, 4645, 4138, 4181, 5140, 6246, 7339, 8335, 9345, 10001, 9953, 9897, 9565, 8526, 7666, 6743, 1882, -7912, -11462, -14053, -9216, -4503, -1303, 584, -943, -4922, -7352, -13866, -15685, -15440, -11839, -13149, -13667, -18666, -20069, -19378, -13970, -11035, -5924, -1887, -747, -3585, -5650, -5442, -6056, -7522, -5290, -3204, -4921, -5086, -7608, -12832, -13406, -12022, -7621, -7889, -7518, -11605, -11737, -11272, -11600, -10616, -5961, -6704, -7261, -7807, -13283, -14773, -15652, -13151, -10148, -11082, -11273, -11479, -11598, -11632, -11588, -11472, -11351, -10829, -10306, -11904, -11610, -11117, -11006, -11466, -12018, -12364, -12443, -12454, -12648, -12622, -11919, -12273, -10571, -3840, 3182, 6927, 7675, 5851, 2427, -1570, -5267, -8132, -10063, -11241, -11985, -12440, -12381, -12305, -12331, -6875, -3155, -8903, -17185, -25181, -30755, -32776, -31287, -27121, -21480, -15459, -9817, -4998, -1083};