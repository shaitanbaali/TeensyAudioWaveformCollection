/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0503 256 samples */
 
const int16_t AKWF_0503_256_DATA [256] = 
{32748, 32755, 32759, 32764, 32766, 32767, 32768, 32767, 32767, 32765, 32762, 32759, 32755, 32752, 32748, 32743, 32737, 32731, 32726, 32719, 32713, 32707, 32700, 32693, 32686, 32679, 32671, 32664, 32656, 32649, 32641, 32633, 32625, 32617, 32609, 32600, 32593, 32584, 32576, 32567, 32560, 32550, 32542, 32534, 32525, 32517, 32509, 32499, 32491, 32482, 32473, 32466, 32457, 32448, 32440, 32431, 32422, 32414, 32406, 32397, 32387, 32116, 33396, 28646, -28375, -33123, -31838, -32107, -32109, -32110, -32112, -32111, -32110, -32108, -32107, -32104, -32100, -32096, -32093, -32088, -32082, -32076, -32071, -32065, -32059, -32053, -32046, -32039, -32032, -32025, -32018, -32011, -32003, -31997, -31989, -31981, -31973, -31965, -31957, -31949, -31941, -31933, -31925, -31916, -31908, -31900, -31892, -31883, -31876, -31867, -31859, -31850, -31842, -31833, -31824, -31818, -31808, -31800, -31792, -31782, -31775, -31765, -31758, -31750, -31740, -31469, -32749, -28000, 29022, 33769, 32485, 32752, 32755, 32756, 32757, 32757, 32756, 32753, 32751, 32748, 32745, 32740, 32736, 32731, 32726, 32720, 32714, 32709, 32703, 32696, 32689, 32682, 32675, 32667, 32660, 32652, 32645, 32638, 32630, 32621, 32614, 32606, 32597, 32589, 32582, 32574, 32565, 32557, 32548, 32539, 32531, 32523, 32515, 32506, 32497, 32489, 32480, 32471, 32464, 32455, 32445, 32437, 32429, 32419, 32412, 32404, 32394, 32385, 31611, 35821, 16110, -34554, -31579, -32053, -32107, -32110, -32112, -32111, -32112, -32110, -32109, -32106, -32103, -32100, -32096, -32091, -32087, -32081, -32075, -32070, -32064, -32058, -32052, -32045, -32038, -32031, -32024, -32016, -32009, -32002, -31995, -31987, -31979, -31971, -31963, -31955, -31947, -31939, -31932, -31923, -31915, -31906, -31899, -31889, -31882, -31874, -31866, -31857, -31849, -31840, -31831, -31823, -31815, -31807, -31798, -31789, -31782, -31772, -31764, -31757, -31747, -31740, -31730, -31721, -31714, -31704};