/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0556 256 samples */
 
const int16_t AKWF_0556_256_DATA [256] = 
{48, 134, 218, 302, 385, 469, 553, 636, 719, 803, 886, 969, 1052, 1135, 1219, 1302, 1384, 1467, 1550, 1633, 1715, 1798, 1881, 1964, 2046, 2129, 2212, 2295, 2377, 2460, 2542, 2625, 2707, 2790, 2872, 2955, 3037, 3119, 3202, 3284, 3367, 3449, 3532, 3614, 3697, 3779, 3862, 3945, 4027, 4110, 4192, 4274, 4357, 4440, 4522, 4604, 4687, 4769, 4852, 4934, 5017, 5099, 5182, 5264, 5347, 5429, 5512, 5594, 5676, 5760, 5843, 5925, 6007, 6090, 6172, 6255, 6339, 6421, 6504, 6586, 6669, 6752, 6835, 6917, 7000, 7083, 7166, 7248, 7332, 7414, 7497, 7579, 7663, 7745, 7828, 7911, 7994, 8077, 8160, 8242, 8325, 8408, 8491, 8574, 8657, 8740, 8823, 8906, 8988, 9072, 9154, 9237, 9320, 9404, 9486, 9570, 9652, 9736, 9818, 9902, 9984, 10067, 10150, 10234, 10317, 10400, 10483, 10566, 10649, 10732, 10814, 10898, 10981, 11064, 11147, 11230, 11313, 11397, 11479, 11563, 11120, 13897, -1098, -30992, -32682, -30597, -28519, -26576, -24817, -23239, -21825, -20550, -19402, -18368, -17431, -16584, -15815, -15114, -14476, -13894, -13359, -12868, -12416, -11998, -11611, -11252, -10916, -10604, -10310, -10034, -9774, -9528, -9295, -9073, -8861, -8659, -8466, -8279, -8100, -7928, -7761, -7600, -7443, -7290, -7142, -6998, -6857, -6719, -6584, -6452, -6322, -6195, -6069, -5947, -5826, -5706, -5589, -5473, -5358, -5246, -5135, -5024, -4915, -4807, -4701, -4595, -4491, -4387, -4285, -4182, -4081, -3981, -3882, -3783, -3685, -3588, -3491, -3395, -3300, -3205, -3111, -3017, -2924, -2831, -2739, -2647, -2556, -2465, -2375, -2285, -2194, -2105, -2016, -1927, -1839, -1750, -1663, -1575, -1488, -1401, -1314, -1227, -1141, -1055, -968, -882, -798, -712, -626, -541, -456, -371, -287, -202, -118, -33};