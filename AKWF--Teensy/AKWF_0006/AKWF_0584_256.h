/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0584 256 samples */
 
const int16_t AKWF_0584_256_DATA [256] = 
{856, 860, 862, 865, 868, 869, 871, 934, 603, 3088, 4728, 4410, 4469, 4471, 4499, 4323, 7227, 8174, 7985, 7893, 8409, 11381, 11413, 11391, 11394, 11391, 11389, 11411, 11261, 11869, 14655, 14608, 14603, 14602, 14638, 14401, 15509, 17803, 17558, 17595, 17588, 17631, 17355, 18895, 20554, 20273, 20315, 20307, 20338, 20111, 21915, 22933, 22716, 22743, 22735, 22733, 22652, 24486, 24974, 24848, 24857, 24853, 24804, 24930, 26569, 26695, 26645, 26640, 26629, 26615, 26602, 26616, 26458, 27517, 28211, 28060, 28071, 28058, 28045, 28030, 28016, 28005, 27976, 28006, 29083, 29213, 29161, 29154, 29139, 29138, 29049, 29749, 30090, 29952, 30471, 30694, 30630, 30622, 30606, 30591, 30575, 30560, 30545, 30517, 30549, 30927, 30931, 30908, 30893, 30880, 30849, 30900, 31098, 31071, 31046, 31082, 31148, 31121, 31106, 31090, 31074, 31058, 31040, 31023, 31005, 31009, 31011, 30992, 30976, 30958, 30172, 34471, -15718, -36398, -31957, -32765, -32754, -32739, -32744, -32744, -32741, -32738, -32733, -32727, -32724, -32701, -32593, -32583, -32573, -32562, -32548, -32553, -32463, -32251, -32254, -32238, -32223, -32202, -32228, -31996, -31697, -31723, -31701, -31685, -31659, -31705, -31237, -30909, -30955, -30928, -30912, -30887, -30921, -30151, -29872, -29914, -29887, -29869, -29865, -29807, -28717, -28560, -28580, -28557, -28541, -28526, -28504, -28516, -28402, -27034, -26889, -26909, -26887, -26871, -26857, -26841, -26827, -26791, -26895, -25402, -24812, -24923, -24887, -24872, -24857, -24808, -24987, -23406, -22552, -22378, -20166, -20109, -20112, -20095, -20082, -20069, -20057, -20045, -19986, -20228, -18875, -17021, -17273, -17214, -17203, -17165, -17304, -16647, -14048, -14287, -13533, -10796, -10891, -10868, -10858, -10848, -10840, -10833, -10825, -10755, -11080, -9077, -7120, -7446, -7377, -7371, -7313, -7595, -4949, -3596, -3870, -3815, -3807, -3797, -3864, -792};