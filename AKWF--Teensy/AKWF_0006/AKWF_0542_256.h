/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0542 256 samples */
 
const int16_t AKWF_0542_256_DATA [256] = 
{2057, 5941, 7919, 10297, 14006, 17324, 18996, 19401, 19395, 18447, 16815, 16803, 19665, 23232, 25822, 27574, 28549, 27770, 25415, 23391, 23121, 22973, 21438, 19357, 17526, 15144, 12879, 12824, 15949, 20453, 24284, 27346, 30009, 30846, 29869, 29260, 29984, 30340, 29096, 26662, 23907, 20314, 16174, 13797, 14451, 15993, 16736, 16837, 16373, 14354, 10974, 8140, 7273, 6738, 5020, 2957, 1332, -662, -2371, -1719, 2249, 7722, 12628, 16851, 20741, 22853, 23182, 23888, 25911, 27540, 27522, 26243, 24558, 21938, 18652, 17003, 18243, 20219, 21240, 21450, 20921, 18668, 14877, 11460, 9837, 8382, 5590, 2298, -689, -4171, -7485, -8532, -6339, -2710, 311, 2625, 4599, 4816, 3284, 2179, 2476, 2471, 929, -1734, -4658, -8354, -12532, -14886, -14147, -12459, -11511, -11143, -11291, -12934, -15885, -18238, -18576, -18536, -19630, -21031, -21950, -23203, -24136, -22674, -17865, -11524, -5728, -595, 4228, 7287, 8574, 10249, 13249, 15854, 16818, 16516, 15804, 14149, 11816, 11105, 13269, 16148, 18049, 19118, 19419, 17965, 14945, 12263, 11339, 10543, 8370, 5657, 3206, 213, -2658, -3308, -770, 3156, 6425, 8933, 11051, 11356, 9860, 8743, 8970, 8843, 7128, 4240, 1039, -2981, -7536, -10316, -10050, -8878, -8493, -8731, -9524, -11854, -15528, -18640, -19772, -20554, -22500, -24779, -26598, -28772, -30646, -30140, -26298, -20938, -16128, -11983, -8152, -6081, -5778, -5080, -3046, -1391, -1365, -2582, -4187, -6708, -9880, -11399, -10009, -7867, -6667, -6256, -6569, -8592, -12132, -15284, -16625, -17783, -20263, -23226, -25869, -28994, -31933, -32591, -29995, -25947, -22495, -19737, -17304, -16615, -17663, -18268, -17463, -16947, -17955, -20075, -22442, -25572, -29174, -30941, -29603, -27311, -25747, -24757, -24273, -25277, -27578, -29281, -28958, -28250, -28673, -29394, -29630, -30196, -30435, -28278, -22771, -15737, -9240, -3328};