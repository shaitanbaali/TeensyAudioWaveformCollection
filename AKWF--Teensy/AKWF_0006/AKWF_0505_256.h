/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0505 256 samples */
 
const int16_t AKWF_0505_256_DATA [256] = 
{28006, 30911, 30375, 30480, 30483, 30485, 30486, 30487, 30486, 30484, 30482, 30479, 30476, 30473, 30469, 30464, 30459, 30455, 30450, 30444, 30438, 30432, 30426, 30419, 30413, 30406, 30399, 30393, 30386, 30378, 30372, 30364, 30357, 30349, 30342, 30334, 30326, 30319, 30311, 30303, 30296, 30287, 30280, 30272, 30264, 30256, 30249, 30240, 30233, 30224, 30217, 30208, 30201, 30192, 30185, 30176, 30169, 30160, 30153, 30144, 30137, 30128, 30121, 30112, 30104, 30096, 30088, 30081, 30071, 30064, 30055, 30048, 30040, 30032, 30024, 30016, 30008, 30000, 29992, 29983, 29976, 29967, 29960, 29951, 29943, 29935, 29927, 29919, 29911, 29903, 29894, 29888, 29878, 29871, 29863, 29856, 29847, 29839, 29831, 29823, 29815, 29808, 29799, 29792, 29783, 29775, 29767, 29759, 29751, 29743, 29735, 29727, 29719, 29711, 29703, 29695, 29687, 29680, 29671, 29663, 29656, 29647, 29640, 29632, 29624, 29616, 29607, 29600, 29592, 29584, 28709, 33492, 10555, -36757, -31870, -32762, -32764, -32766, -32767, -32767, -32766, -32765, -32762, -32760, -32756, -32752, -32749, -32744, -32738, -32733, -32728, -32722, -32715, -32709, -32702, -32695, -32689, -32681, -32673, -32666, -32658, -32652, -32643, -32636, -32627, -32620, -32611, -32603, -32595, -32586, -32579, -32571, -32561, -32553, -32546, -32537, -32528, -32519, -32512, -32503, -32494, -32485, -32476, -32468, -32460, -32451, -32442, -32434, -32424, -32417, -32409, -32400, -32391, -32382, -32373, -32364, -32356, -32348, -32339, -32330, -32322, -32312, -32304, -32296, -32288, -32279, -32270, -32261, -32252, -32243, -32234, -32227, -32218, -32209, -32201, -32191, -32183, -32174, -32167, -32158, -32149, -32140, -32131, -32122, -32115, -32106, -32097, -32089, -32079, -32071, -32063, -32055, -32046, -32037, -32028, -32019, -32012, -32003, -31994, -31985, -31976, -31967, -31960, -31952, -31942, -31934, -31925, -31916, -31909, -31900, -31891, -31882, -31873, -31866, -31858, -31848};