/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0528 256 samples */
 
const int16_t AKWF_0528_256_DATA [256] = 
{6940, 6940, 6940, 6940, 6940, 6940, 6940, 6940, 6940, 6940, 6940, 6940, 6940, 6940, 6940, 6940, 6308, 9754, -19110, -35469, -32163, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32758, -32770, -32809, -26809, -25587, -25880, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25826, -25415, -27657, -8883, 1756, -394, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0};