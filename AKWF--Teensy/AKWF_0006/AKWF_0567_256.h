/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0567 256 samples */
 
const int16_t AKWF_0567_256_DATA [256] = 
{2076, 4955, 7148, 8989, 10572, 11957, 13190, 14292, 15286, 16188, 17006, 17751, 18429, 19044, 19605, 20111, 20567, 20976, 21339, 21658, 21935, 22171, 22367, 22524, 22641, 22777, 22525, 23999, 28136, 28895, 29513, 29958, 30304, 30577, 30795, 30964, 31091, 31183, 31217, 31332, 31432, 31981, 32681, 10214, -180, -3248, -6364, -8764, -10782, -12540, -14097, -15492, -16762, -17924, -18991, -19983, -20903, -21759, -22561, -23310, -24011, -24671, -25289, -25869, -26414, -26925, -27404, -27852, -28271, -28662, -29026, -29363, -29675, -29963, -30225, -30464, -30680, -30874, -31045, -31193, -31320, -31425, -31509, -31572, -31607, -31665, -31008, -30536, -30905, -27834, -21806, -20844, -19830, -19102, -18516, -18029, -17618, -17268, -16970, -16718, -16505, -16331, -16192, -16085, -15962, -16014, -15815, 2588, 10723, 13129, 15535, 17352, 18841, 20095, 21164, 22075, 22855, 23517, 24073, 24531, 24897, 25174, 25387, 25424, 25750, 29550, 30867, 31349, 31778, 32089, 32326, 32506, 32634, 32409, 34137, 15254, 1781, -957, -4182, -6605, -8648, -10418, -11997, -13420, -14714, -15908, -17012, -18037, -19000, -19900, -20746, -21546, -22300, -23012, -23688, -24328, -24933, -25508, -26053, -26568, -27058, -27521, -27958, -28372, -28761, -29127, -29472, -29793, -30094, -30374, -30632, -30870, -31089, -31288, -31467, -31622, -31708, -31758, -31805, -31800, -30380, -29821, -29736, -29460, -29800, -20000, -14376, -13040, -11582, -10494, -9600, -8844, -8196, -7640, -7157, -6740, -6384, -6081, -5829, -5624, -5464, -5327, -5114, -5984, 7583, 17761, 19355, 21428, 22913, 24139, 25179, 26076, 26862, 27554, 28165, 28706, 29183, 29601, 29967, 30283, 30551, 30774, 30952, 31090, 31189, 31222, 31366, 31366, 32534, 30874, 1996, -7764, -11791, -15357, -18120, -20417, -22369, -24042, -25494, -26753, -27840, -28778, -29576, -30245, -30793, -31224, -31542, -31742, -31913, -30600, -29868, -29795, -29287, -30865, -13985, -536};