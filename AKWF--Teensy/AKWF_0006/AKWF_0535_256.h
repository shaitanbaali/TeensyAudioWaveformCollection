/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0535 256 samples */
 
const int16_t AKWF_0535_256_DATA [256] = 
{23172, 23201, 18181, 23467, 20829, 17980, 17084, 16652, 16466, 16391, 16353, 16325, 16304, 16299, 16310, 16322, 16321, 16309, 16297, 16298, 16312, 16322, 16320, 16306, 16296, 16300, 16314, 16323, 16318, 16303, 16296, 16302, 16317, 16323, 16316, 16301, 16296, 16305, 16319, 16323, 16313, 16299, 16297, 16307, 16321, 16322, 16310, 16298, 16298, 16310, 16322, 16321, 16307, 16297, 16299, 16313, 16323, 16319, 16305, 16296, 16301, 16316, 16323, 16317, 16302, 16296, 16303, 16318, 16323, 16314, 16300, 16296, 16306, 16320, 16322, 16312, 16298, 16297, 16309, 16321, 16321, 16309, 16297, 16298, 16312, 16322, 16320, 16306, 16296, 16300, 16314, 16323, 16318, 16303, 16296, 16302, 16317, 16323, 16316, 16301, 16296, 16305, 16319, 16323, 16313, 16299, 16297, 16307, 16321, 16322, 16310, 16298, 16298, 16310, 16322, 16321, 16307, 16297, 16299, 16313, 16323, 16319, 16305, 16296, 16301, 16316, 16323, 16317, 16302, 16296, 16303, 16318, 16323, 16314, 16300, 16296, 16306, 16320, 16322, 16312, 16298, 16297, 16309, 16321, 16321, 16309, 16297, 16298, 16312, 16322, 16320, 16306, 16296, 16300, 16314, 16323, 16318, 16303, 16296, 16302, 16317, 16323, 16316, 16301, 16296, 16305, 16319, 16323, 16313, 16299, 16297, 16307, 16321, 16322, 16310, 16298, 16298, 16310, 16322, 16321, 16307, 16297, 16299, 16313, 16323, 16319, 16305, 16296, 16301, 16316, 16323, 16317, 16302, 16296, 16303, 16318, 16323, 16314, 16300, 16296, 16306, 16320, 16322, 16312, 16298, 16297, 16309, 16321, 16321, 16309, 16297, 16298, 16312, 16322, 16320, 16306, 16296, 16300, 16314, 16323, 16057, 17799, 10108, -25916, -24367, -20535, -18020, -17073, -16635, -16448, -16371, -16335, -16308, -16286, -16280, -16290, -16303, -16303, -16292, -16279, -16279, -16292, -16303, -16302, -16289, -16278, -16281, -16294, -16304, -16300, -16286, -16278, -16283, -16430, -15477, -19448};