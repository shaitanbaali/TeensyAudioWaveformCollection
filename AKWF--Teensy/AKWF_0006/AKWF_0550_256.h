/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0550 256 samples */
 
const int16_t AKWF_0550_256_DATA [256] = 
{182, 506, 840, 1193, 1561, 1942, 2328, 2711, 3088, 3450, 3791, 4114, 4416, 4698, 4967, 5225, 5478, 5732, 5991, 6256, 6531, 6812, 7098, 7386, 7672, 7951, 8221, 8478, 8718, 8946, 9160, 9363, 9559, 9750, 9939, 10131, 10327, 10526, 10731, 10939, 11149, 11359, 11565, 11768, 11962, 12148, 12327, 12499, 12664, 12825, 12985, 13145, 13308, 13474, 13644, 13821, 14002, 14185, 14371, 14558, 14743, 14928, 15109, 15287, 15465, 15639, 15813, 15989, 16166, 16347, 16533, 16724, 16920, 17121, 17327, 17536, 17748, 17962, 18176, 18392, 18608, 18823, 19040, 19257, 19477, 19700, 19925, 20155, 20390, 20628, 20872, 21118, 21369, 21622, 21876, 22133, 22391, 22649, 22907, 23166, 23427, 23688, 23951, 24217, 24484, 24754, 25026, 25301, 25578, 25857, 26137, 26418, 26697, 26979, 27259, 27539, 27818, 28098, 28376, 28654, 28934, 29212, 29392, 29861, 29894, -2434, -21937, -27675, -29831, -21132, -20580, -26041, -26369, -24299, -26322, -29717, -29515, -28294, -28783, -28692, -26565, -24337, -23031, -21455, -19425, -18096, -17657, -17414, -17370, -17926, -18851, -19669, -20348, -20963, -21307, -21198, -20737, -20041, -19118, -18036, -16976, -16073, -15373, -14931, -14807, -14983, -15386, -15943, -16580, -17195, -17690, -18009, -18117, -18002, -17683, -17211, -16653, -16079, -15561, -15162, -14924, -14867, -14985, -15255, -15628, -16050, -16463, -16811, -17049, -17150, -17105, -16924, -16632, -16268, -15876, -15504, -15188, -14960, -14835, -14814, -14882, -15015, -15179, -15338, -15457, -15506, -15466, -15330, -15101, -14792, -14428, -14036, -13642, -13275, -12955, -12692, -12489, -12341, -12233, -12146, -12058, -11947, -11794, -11585, -11314, -10985, -10603, -10180, -9736, -9288, -8851, -8442, -8068, -7732, -7432, -7160, -6905, -6655, -6395, -6113, -5801, -5454, -5072, -4659, -4222, -3772, -3322, -2878, -2455, -2057, -1684, -1339, -1018, -712, -417, -114};