/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0590 256 samples */
 
const int16_t AKWF_0590_256_DATA [256] = 
{575, 1662, 2728, 3796, 4862, 5930, 6998, 8062, 9127, 10194, 11258, 12323, 13387, 14448, 15512, 16574, 17634, 18694, 19756, 20814, 22010, 22315, 27248, 33437, 32585, 32724, 32707, 32688, 32670, 32650, 32630, 32610, 32589, 32568, 32546, 32525, 32502, 32480, 32459, 32436, 32412, 32390, 32367, 32342, 32318, 32295, 32272, 32247, 32223, 32201, 32117, 32406, 31107, 23536, 23116, 22836, 22494, 22167, 21842, 21516, 21192, 20865, 20541, 20217, 19892, 19569, 19244, 18921, 18598, 18274, 17952, 17629, 17307, 16984, 16662, 16341, 16020, 15698, 15377, 15055, 14735, 14414, 14094, 13773, 13453, 13133, 12814, 12494, 12174, 11855, 11536, 11217, 10899, 10580, 10262, 9944, 9625, 9308, 8991, 8672, 8356, 8038, 7721, 7405, 7089, 6771, 6455, 6138, 5822, 5508, 5191, 4876, 4561, 4246, 3930, 3616, 3301, 2987, 2672, 2358, 2044, 1731, 1417, 1104, 791, 478, 165, -147, -460, -773, -1084, -1397, -1709, -2019, -2332, -2644, -2955, -3266, -3576, -3887, -4199, -4507, -4818, -5129, -5437, -5748, -6058, -6367, -6676, -6985, -7294, -7602, -7912, -8219, -8528, -8836, -9143, -9452, -9758, -10066, -10374, -10680, -10987, -11294, -11601, -11907, -12214, -12518, -12826, -13132, -13436, -13742, -14047, -14352, -14657, -14963, -15268, -15571, -15876, -16180, -16484, -16787, -17090, -17394, -17698, -18001, -18303, -18607, -18909, -19211, -19513, -19816, -20118, -20419, -20721, -21023, -21324, -21625, -21926, -22227, -22527, -22829, -23213, -23027, -25492, -32628, -32221, -32264, -32246, -32225, -32204, -32181, -32160, -32138, -32115, -32092, -32069, -32046, -32022, -32000, -31977, -31952, -31928, -31905, -31881, -31856, -31832, -31808, -31785, -31760, -31736, -31710, -31591, -32099, -25074, -21551, -21006, -19835, -18754, -17674, -16598, -15519, -14440, -13365, -12287, -11211, -10137, -9061, -7986, -6914, -5839, -4766, -3695, -2625, -1557, -468};