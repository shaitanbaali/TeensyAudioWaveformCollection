/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0520 256 samples */
 
const int16_t AKWF_0520_256_DATA [256] = 
{647, 2035, 3438, 4865, 6276, 7635, 8903, 10051, 11075, 11985, 12794, 13537, 14248, 14983, 15825, 16844, 18055, 19426, 20874, 22305, 23653, 24875, 25958, 26919, 27779, 28556, 29266, 29903, 30448, 30875, 31165, 31301, 31244, 30936, 30331, 29424, 28269, 26954, 25585, 24264, 23054, 21991, 21080, 20297, 19615, 19033, 18574, 18253, 18033, 17815, 17504, 17058, 16492, 15866, 15238, 14639, 14080, 13547, 13017, 12465, 11863, 11189, 10430, 9557, 8502, 7189, 5556, 3598, 1393, -943, -3267, -5435, -7357, -8975, -10277, -11289, -12058, -12636, -13091, -13492, -13919, -14453, -15122, -15887, -16665, -17356, -17892, -18255, -18461, -18549, -18559, -18518, -18430, -18286, -18069, -17773, -17407, -16997, -16578, -16182, -15831, -15534, -15281, -15053, -14822, -14557, -14233, -13828, -13334, -12752, -12089, -11355, -10564, -9719, -8831, -7906, -6944, -5951, -4932, -3888, -2825, -1749, -655, 450, 1571, 2716, 3883, 5077, 6297, 7530, 8760, 9976, 11158, 12300, 13392, 14417, 15373, 16254, 17058, 17787, 18442, 19019, 19518, 19936, 20271, 20529, 20712, 20826, 20877, 20873, 20822, 20728, 20599, 20443, 20266, 20081, 19894, 19711, 19538, 19367, 19175, 18903, 18467, 17793, 16864, 15732, 14505, 13318, 12265, 11390, 10663, 10002, 9318, 8551, 7683, 6732, 5722, 4650, 3504, 2267, 933, -462, -1862, -3213, -4472, -5631, -6723, -7777, -8820, -9862, -10875, -11827, -12711, -13568, -14505, -15645, -17050, -18690, -20435, -22107, -23566, -24751, -25689, -26476, -27211, -27936, -28640, -29267, -29772, -30164, -30502, -30862, -31294, -31779, -32243, -32594, -32760, -32726, -32525, -32218, -31871, -31518, -31156, -30749, -30256, -29659, -28972, -28241, -27523, -26849, -26217, -25601, -24971, -24312, -23626, -22914, -22178, -21402, -20555, -19609, -18556, -17407, -16215, -15039, -13911, -12840, -11800, -10739, -9626, -8444, -7189, -5891, -4575, -3263, -1967, -643};