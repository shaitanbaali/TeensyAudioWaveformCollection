/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0591 256 samples */
 
const int16_t AKWF_0591_256_DATA [256] = 
{276, 969, 1648, 2328, 3007, 3687, 4367, 5045, 5724, 6403, 7080, 7758, 8436, 9111, 9789, 10465, 11140, 11816, 12491, 13164, 13839, 14514, 15186, 15861, 16534, 17205, 17878, 18550, 19220, 19893, 20563, 21232, 21902, 22572, 23333, 23477, 30374, 32999, 32384, 32448, 32406, 32364, 32322, 32279, 32236, 32192, 32149, 32105, 32059, 32015, 31971, 31923, 31888, 31974, 32043, 32106, 32170, 32234, 32298, 32361, 32424, 32488, 32552, 32613, 32675, 32754, 32124, 31882, 31813, 31707, 31603, 31502, 31400, 31298, 31197, 31094, 30993, 30891, 30790, 30688, 30585, 30484, 30383, 30281, 30180, 30078, 29975, 29875, 29774, 29673, 29569, 29468, 29368, 29267, 29166, 29065, 28964, 28864, 28760, 28659, 28558, 28457, 28359, 28259, 28157, 28056, 27956, 27855, 27754, 27653, 27554, 27454, 27353, 27252, 27153, 27054, 26952, 26853, 26753, 26653, 26554, 26453, 26354, 26253, 26155, 26054, 25882, 26060, 24814, 12573, 1088, -9236, -23455, -33606, -32421, -32634, -32610, -32584, -32556, -32528, -32498, -32467, -32435, -32402, -32369, -32333, -32298, -32262, -32225, -32189, -32150, -32113, -32074, -32034, -31995, -31956, -31917, -31876, -31836, -31796, -31755, -31714, -31674, -31632, -31591, -31550, -31509, -31468, -31426, -31385, -31343, -31301, -31260, -31219, -31176, -31134, -31093, -31052, -31010, -30967, -30925, -30884, -30843, -30801, -30758, -30716, -30674, -30634, -30592, -30549, -30507, -30465, -30424, -30382, -30347, -30273, -30169, -30227, -30276, -30328, -30379, -30430, -30480, -30531, -30582, -30634, -30684, -30733, -30793, -30790, -30673, -30571, -30467, -30364, -30260, -30157, -30053, -29948, -29844, -29741, -29638, -29535, -29431, -29215, -29729, -26700, -19838, -19741, -18943, -18251, -17558, -16868, -16177, -15486, -14796, -14106, -13417, -12729, -12040, -11351, -10665, -9977, -9289, -8605, -7918, -7231, -6547, -5862, -5176, -4494, -3809, -3126, -2443, -1761, -1081, -387};