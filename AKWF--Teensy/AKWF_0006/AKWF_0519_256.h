/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0519 256 samples */
 
const int16_t AKWF_0519_256_DATA [256] = 
{583, 2063, 3522, 4983, 6438, 7878, 9294, 10669, 11999, 13274, 14479, 15601, 16616, 17506, 18270, 18910, 19434, 19860, 20206, 20490, 20728, 20932, 21113, 21285, 21465, 21674, 21914, 22177, 22445, 22702, 22942, 23163, 23365, 23547, 23706, 23838, 23939, 24005, 24028, 24004, 23927, 23793, 23587, 23284, 22858, 22295, 21581, 20726, 19749, 18669, 17515, 16320, 15105, 13897, 12717, 11574, 10480, 9442, 8445, 7481, 6528, 5578, 4636, 3708, 2795, 1907, 1045, 207, -607, -1398, -2164, -2895, -3591, -4243, -4849, -5414, -5944, -6443, -6922, -7387, -7842, -8288, -8724, -9146, -9552, -9934, -10287, -10604, -10880, -11113, -11297, -11428, -11505, -11527, -11491, -11398, -11250, -11046, -10790, -10483, -10128, -9724, -9273, -8778, -8236, -7647, -7013, -6332, -5609, -4850, -4054, -3226, -2375, -1502, -616, 276, 1174, 2070, 2957, 3836, 4698, 5539, 6359, 7153, 7918, 8655, 9362, 10038, 10686, 11304, 11893, 12458, 12998, 13516, 14017, 14502, 14976, 15438, 15888, 16320, 16713, 17047, 17304, 17476, 17570, 17600, 17584, 17537, 17467, 17371, 17242, 17076, 16870, 16625, 16345, 16028, 15665, 15246, 14766, 14221, 13613, 12956, 12257, 11524, 10762, 9972, 9152, 8310, 7444, 6569, 5694, 4816, 3916, 2971, 1951, 847, -331, -1570, -2841, -4117, -5396, -6674, -7951, -9235, -10511, -11766, -12987, -14164, -15303, -16420, -17526, -18625, -19717, -20784, -21813, -22795, -23724, -24605, -25440, -26234, -26988, -27695, -28345, -28935, -29463, -29932, -30359, -30747, -31102, -31428, -31719, -31973, -32196, -32385, -32540, -32662, -32741, -32768, -32735, -32640, -32484, -32270, -32010, -31709, -31363, -30970, -30525, -30025, -29471, -28860, -28198, -27492, -26741, -25942, -25096, -24196, -23241, -22239, -21187, -20096, -18983, -17849, -16709, -15573, -14438, -13311, -12195, -11080, -9954, -8798, -7592, -6333, -5023, -3665, -2273, -824};