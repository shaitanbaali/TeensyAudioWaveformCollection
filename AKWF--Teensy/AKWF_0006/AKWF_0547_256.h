/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0547 256 samples */
 
const int16_t AKWF_0547_256_DATA [256] = 
{3218, 2941, 7108, 10818, 13846, 13611, 10302, 8343, 10850, 13573, 18708, 18844, 21993, 24284, 23533, 25557, 26325, 23474, 27777, 27484, 29411, 31204, 25393, 23685, 27327, 25597, 29150, 27890, 25303, 26485, 24959, 23035, 24915, 21984, 22597, 22606, 21700, 17392, 9964, 3962, 2581, 1657, 3475, 660, 1256, 1402, -1106, -485, -804, -4487, -807, -1566, 9, 1525, -4504, -6385, -2861, -4636, -1027, -2093, -4298, -2501, -3140, -3870, -462, -1537, 1247, 3708, 5466, 3968, -589, -3763, -2433, -843, 3216, 2344, 4558, 5994, 4470, 5808, 5985, 2630, 6521, 5904, 7595, 9235, 3347, 1630, 5330, 3717, 7435, 6382, 4034, 5484, 4244, 2618, 4803, 2174, 3085, 3380, 2748, -1303, -8489, -14272, -15451, -16189, -14200, -16859, -16116, -15825, -18190, -17418, -17572, -21071, -17181, -17699, -15846, -14005, -19659, -21109, -17094, -18316, -14087, -14465, -15920, -13305, -13066, -12861, -8465, -8508, -4652, -1092, 1782, 1407, -2026, -4089, -1674, 970, 6038, 6121, 9230, 11491, 10720, 12733, 13498, 10651, 14965, 14688, 16636, 18454, 12673, 10993, 14669, 12973, 16560, 15332, 12777, 13990, 12493, 10594, 12498, 9588, 10219, 10239, 9342, 5039, -2387, -8392, -9782, -10715, -8914, -11749, -11174, -11052, -13590, -12999, -13350, -17065, -13418, -14210, -12670, -11185, -17241, -19150, -15648, -17442, -13846, -14917, -17123, -15319, -15940, -16643, -13199, -14225, -11381, -8847, -7002, -8400, -12840, -15882, -14406, -12649, -8404, -9075, -6642, -4970, -6237, -4624, -4155, -7197, -2973, -3239, -1181, 843, -4640, -5935, -1799, -2960, 1224, 651, -1201, 754, 31, -1067, 1652, -433, 1026, 1878, 1804, -1689, -8314, -13535, -14157, -14337, -11798, -13913, -12629, -11809, -13653, -12369, -12027, -15039, -10677, -10737, -8442, -6173, -11416, -12473, -8083, -8949, -4382, -4441, -5594, -2721, -2112, -2077};