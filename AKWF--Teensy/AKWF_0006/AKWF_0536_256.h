/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0536 256 samples */
 
const int16_t AKWF_0536_256_DATA [256] = 
{3834, -5106, 11521, 12113, 1025, -4080, -6458, -6553, -5397, -3834, -2316, -997, 76, 869, 1376, 1626, 1681, 1615, 1477, 1302, 1116, 939, 782, 642, 501, 345, 184, 36, -88, -193, -292, -390, -480, -539, -564, -565, -559, -553, -539, -502, -718, 713, -5627, 993, 1241, -4584, -5793, -5246, -3853, -2229, -643, 818, 2130, 3232, 4056, 4562, 4731, 4602, 4236, 3716, 3118, 2494, 1884, 1306, 766, 276, -160, -555, -916, -1257, -1574, -1852, -2072, -2215, -2270, -2243, -2148, -1999, -1801, -1557, -1271, -963, -653, -358, -126, 889, -2636, 4250, 16513, 4162, -1953, -5203, -5904, -5013, -3501, -1967, -637, 443, 1266, 1813, 2076, 2092, 1943, 1720, 1158, 2382, -3285, -6494, -4798, -5123, -3723, -2654, 2911, -8269, -5767, 2913, 7113, 8958, 8889, 7735, 6157, 4523, 2978, 1601, 438, -488, -1183, -1680, -1945, -2646, 658, -11716, -9044, -2320, 1020, 2544, 2664, 2063, 1271, 548, -24, -425, -649, -697, -598, -395, -143, 119, 370, 598, 799, 955, 1049, 1065, 1013, 910, 767, 595, 408, 220, 49, -88, -191, -268, -330, -377, -403, -398, -634, 419, 1701, -4913, -6592, -8516, -19446, -8358, -210, 5099, 7862, 8708, 8441, 7625, 6557, 5377, 4176, 3045, 2046, 1216, 543, -16, -508, -951, -1350, -1681, -1936, -2111, -2219, -2267, -2251, -2163, -2007, -1799, -1565, -1315, -1053, -777, -491, -211, 43, 264, 457, 631, 787, 984, 350, 3866, -3579, -8696, -355, 3442, 5355, 5580, 4800, 3647, 2488, 1463, 598, -94, -592, -898, -1036, -1052, -1002, -921, -828, -714, -584, -450, -348, -299, -298, -322, -354, -379, -393, -400, -398, -378, -333, -265, -186, -108, -39, -90, 802, -2535};