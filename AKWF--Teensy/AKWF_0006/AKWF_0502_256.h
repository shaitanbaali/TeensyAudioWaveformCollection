/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0502 256 samples */
 
const int16_t AKWF_0502_256_DATA [256] = 
{32750, 32757, 32761, 32765, 32767, 32768, 32767, 32767, 32767, 32765, 32762, 32759, 32755, 32751, 32746, 32741, 32737, 32731, 32725, 32719, 32713, 32706, 32699, 32692, 32686, 32678, 32670, 32663, 32656, 32648, 32639, 32632, 32624, 32616, 32608, 32600, 32591, 32584, 32574, 32567, 32559, 32549, 32541, 32533, 32524, 32515, 32508, 32499, 32490, 32481, 32473, 32465, 32456, 32447, 32438, 32431, 32422, 32412, 32403, 32395, 32387, 32378, 32370, 32360, 32352, 32345, 32335, 32326, 32317, 32309, 32301, 32292, 32283, 32274, 32266, 32258, 32248, 32240, 32230, 32222, 32215, 32205, 32196, 32188, 32179, 32171, 32163, 32153, 32144, 32137, 32128, 32119, 32110, 32101, 32094, 32085, 32076, 32067, 32059, 32051, 32042, 32033, 32023, 32016, 32008, 31998, 31989, 31982, 31973, 31964, 31956, 31947, 31939, 31930, 31921, 31912, 31905, 31896, 31887, 31878, 31871, 31861, 31617, 32725, 28710, -27114, -32415, -31010, -31295, -31297, -31299, -31300, -31301, -31299, -31297, -31295, -31293, -31289, -31286, -31283, -31278, -31273, -31266, -31262, -31256, -31251, -31243, -31237, -31231, -31224, -31217, -31210, -31203, -31196, -31188, -31181, -31174, -31166, -31158, -31151, -31143, -31135, -31127, -31119, -31111, -31103, -31096, -31087, -31079, -31071, -31063, -31054, -31047, -31038, -31030, -31022, -31014, -31005, -30997, -30990, -30980, -30974, -30964, -30956, -30948, -30940, -30932, -30923, -30915, -30907, -30898, -30891, -30882, -30873, -30866, -30857, -30849, -30841, -30833, -30824, -30816, -30808, -30799, -30791, -30784, -30774, -30767, -30758, -30749, -30742, -30733, -30726, -30716, -30709, -30701, -30691, -30685, -30675, -30667, -30659, -30651, -30643, -30634, -30627, -30618, -30610, -30602, -30593, -30586, -30577, -30569, -30560, -30553, -30544, -30536, -30529, -30519, -30512, -30503, -30496, -30487, -30479, -30471, -30462, -30455, -30446, -30438, -30429, -30422, -30413, -30405, -30398, -30389, -30381, -30372, -30365};