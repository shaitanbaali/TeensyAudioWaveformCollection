/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0574 256 samples */
 
const int16_t AKWF_0574_256_DATA [256] = 
{10352, 10246, 10147, 10047, 9937, 9828, 9727, 9619, 9505, 9402, 9296, 9184, 9078, 8981, 8876, 8773, 8684, 8592, 8499, 8418, 8344, 8266, 8196, 8138, 8078, 8021, 7978, 7941, 7901, 7875, 7854, 7831, 7817, 7813, 7806, 7801, 7808, 7812, 7815, 7823, 7834, 7838, 7840, 7849, 7848, 7840, 7835, 7826, 7802, 7774, 7743, 7698, 7642, 7583, 7511, 7424, 7331, 7230, 7112, 6982, 6849, 6707, 6547, 6381, 6210, 6024, 5836, 5643, 5442, 5238, 5034, 4828, 4622, 4420, 4223, 4030, 3840, 3663, 3490, 3328, 3180, 3043, 2918, 2810, 2716, 2636, 2351, 3495, -7274, -14580, -15686, -18052, -20202, -22271, -24189, -25967, -27608, -29024, -30227, -31217, -31925, -32383, -32643, -32746, -32727, -32571, -32285, -31737, -30817, -29410, -27412, -24840, -21818, -18495, -15036, -11532, -7941, -4203, -174, 3883, 7239, 10058, 9021, 87, 823, 1494, 2138, 2794, 3438, 4063, 4661, 5217, 5711, 6138, 6479, 6714, 6837, 6832, 6694, 6416, 5988, 5453, 4753, 3891, 2890, 1761, 506, -881, -2385, -4000, -5740, -7543, -10051, 12, 3080, 2370, 2505, 2530, 2572, 2627, 2691, 2766, 2852, 2944, 3039, 3142, 3247, 3349, 3452, 3554, 3647, 3735, 3818, 3887, 3944, 3991, 4023, 4039, 4039, 4025, 3995, 3944, 3880, 3796, 3692, 3575, 3443, 3295, 3133, 2960, 2775, 2581, 2378, 2173, 1962, 1744, 1526, 1307, 1089, 874, 664, 458, 260, 67, -116, -292, -462, -618, -768, -915, -1054, -1183, -1311, -1433, -1549, -1665, -1780, -1895, -2010, -2130, -2252, -2375, -2508, -2650, -2794, -2945, -3106, -3270, -3436, -3608, -3782, -3950, -4117, -4283, -4437, -4578, -4711, -4822, -4912, -4980, -5022, -5029, -5001, -4937, -4827, -4672, -4467, -4222, -3925, -3569, -3165, -2713, -2219, -1686, -1119, -509};