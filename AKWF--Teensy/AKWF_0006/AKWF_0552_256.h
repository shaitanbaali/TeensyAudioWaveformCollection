/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0552 256 samples */
 
const int16_t AKWF_0552_256_DATA [256] = 
{306, 1257, 2165, 3058, 3941, 4818, 5699, 6583, 7476, 8375, 9273, 10167, 11052, 11918, 12760, 13573, 14351, 15097, 15808, 16487, 17141, 17772, 18386, 18989, 19582, 20168, 20748, 21319, 21881, 22429, 22960, 23469, 23956, 24416, 24851, 25260, 25645, 26011, 26361, 26694, 27019, 27336, 27645, 27950, 28251, 28542, 28827, 29100, 29359, 29605, 29835, 30048, 30246, 30428, 30597, 30757, 30907, 31049, 31189, 31323, 31454, 31582, 31707, 31826, 31940, 32045, 32142, 32229, 32307, 32374, 32432, 32483, 32527, 32564, 32597, 32627, 32654, 32679, 32702, 32723, 32741, 32756, 32764, 32768, 32767, 32759, 32745, 32725, 32698, 32667, 32633, 32595, 32555, 32513, 32468, 32423, 32376, 32327, 32276, 32222, 32164, 32103, 32035, 31966, 31892, 31813, 31732, 31647, 31560, 31472, 31382, 31290, 31198, 31104, 31008, 30912, 30813, 30711, 30607, 30500, 30389, 30277, 30162, 30044, 29924, 29804, 29681, 29557, 28935, 31262, 18180, -14707, -22507, -29651, -25047, -19935, -23268, -27629, -26131, -25966, -29690, -31802, -31007, -30914, -31867, -31175, -29166, -27853, -26978, -25520, -24104, -23617, -23667, -23782, -24287, -25341, -26507, -27501, -28416, -29203, -29624, -29629, -29362, -28877, -28185, -27412, -26726, -26208, -25897, -25857, -26113, -26620, -27307, -28101, -28924, -29678, -30283, -30699, -30902, -30892, -30703, -30390, -30022, -29662, -29378, -29222, -29222, -29387, -29704, -30139, -30641, -31158, -31634, -32020, -32281, -32398, -32370, -32214, -31961, -31650, -31324, -31024, -30785, -30626, -30555, -30570, -30649, -30764, -30882, -30969, -30992, -30929, -30764, -30495, -30131, -29688, -29188, -28662, -28132, -27622, -27147, -26714, -26322, -25960, -25612, -25260, -24879, -24451, -23963, -23401, -22762, -22056, -21285, -20468, -19623, -18763, -17906, -17064, -16241, -15438, -14654, -13877, -13098, -12306, -11486, -10631, -9735, -8796, -7818, -6809, -5772, -4727, -3682, -2648, -1636, -630};