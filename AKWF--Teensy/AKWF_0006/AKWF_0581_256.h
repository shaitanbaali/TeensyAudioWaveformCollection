/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0581 256 samples */
 
const int16_t AKWF_0581_256_DATA [256] = 
{1268, 3625, 5934, 8248, 10561, 12875, 15191, 17501, 19814, 22119, 24463, 26556, 27948, 29444, 29103, 27539, 26161, 24745, 23328, 21915, 20498, 19081, 17669, 16250, 14835, 13423, 12004, 10590, 9178, 7761, 6348, 4936, 3521, 2110, 716, -771, -1546, -1485, -1504, -1507, -1510, -1513, -1514, -1516, -1518, -1520, -1521, -1522, -1524, -1524, -1525, -1526, -1525, -1525, -1525, -1525, -1525, -1525, -1525, -1525, -1525, -1525, -1525, -1526, -1524, -1523, -1524, -1524, -1522, -1521, -1522, -1521, -1519, -1520, -1519, -1517, -1518, -1517, -1515, -1516, -1522, -1498, -1598, -2810, -4265, -5668, -7077, -8491, -9903, -11312, -12724, -14136, -15545, -16955, -18364, -19771, -21181, -22587, -23993, -25402, -26805, -28211, -29610, -31013, -32434, -31796, -29797, -30806, -10778, 2144, 1052, 2693, 3899, 5011, 6898, -5172, -6774, -3193, -747, 1881, 4504, 7122, 9748, 12369, 14986, 17596, 20277, 22101, 23208, 24519, 25225, 24078, 22849, 21645, 20430, 19219, 18005, 16789, 15578, 14364, 13148, 11936, 10722, 9508, 8296, 7082, 5869, 4659, 3446, 2234, 1031, -202, -1311, -1463, -1435, -1446, -1449, -1452, -1453, -1455, -1457, -1458, -1459, -1460, -1460, -1461, -1463, -1462, -1462, -1462, -1462, -1462, -1462, -1462, -1462, -1462, -1462, -1463, -1461, -1460, -1460, -1461, -1460, -1458, -1458, -1459, -1457, -1456, -1457, -1455, -1454, -1455, -1454, -1452, -1453, -1451, -1450, -1451, -1449, -1448, -1448, -1447, -1447, -1446, -1445, -1445, -1444, -1442, -1442, -1441, -1441, -1440, -1438, -1439, -1438, -1436, -1437, -1435, -1435, -1434, -1433, -1442, -1399, -1906, -2863, -3758, -4665, -5571, -6476, -7382, -8289, -9193, -10099, -11004, -11908, -12812, -13717, -14619, -15523, -16427, -17328, -18231, -19132, -20011, -21009, -21068, -20793, -16966, -194, 1269, 2393, 5047, 43, -6712, -3100, -986};